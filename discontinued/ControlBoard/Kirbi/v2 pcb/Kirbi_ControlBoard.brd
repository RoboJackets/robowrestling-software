# Repository RoboJackets/robowrestling-software

File README.md:

# robowrestling-software

## Setup Guide

### PlatformIO Setup

PlatformIO is the platform that we use to program our bot, using the Arduino library.
It is most well-integrated with VS Code. Therefore, VS Code is the recommended editor for our bot code.
If you don't have VS Code, you can get it from [here](https://code.visualstudio.com/) or through your OS's package manager
(winget for Windows, brew or MacPorts for macOS, or whatever your Linux distro uses).

There is some other support for other editors, but you'll be mostly on your own.
In theory, you could use something like Vim and use the PlatformIO command-line tools, but your code completion and error detection may not work.

The VS Code installation instructions are as follows:

1. Go to the [PlatformIO website](https://platformio.org/platformio-ide)

2. Click the "Get for VS Code" button and follow the install instructions
    - If you wish to use another IDE, you can try looking for instructions [on this page](https://platformio.org/install/integration). However, VS Code will work best (at least from my experience).

3. When you open a folder to work on code, make sure that the folder you open has a `platformio.ini` file directly in it. It has to be directly in the folder.
    - If you're going to make a new project, then
        - Click the PlatformIO icon on the side bar of VS Code and click "Create New Project"
        - In the new tab, click "New Project" on the right
        - Select your board (likely a Teensy 4.1) and the Arudino framework
        - Give it a name and optionally choose a location by unchecking "Use Default Location"
    - Alternatively, you can use `pio init` in a new folder if you have the CLI installed

### Git/Github Setup

This is the repository for our code. The other robowrestling repository isn't used for software.
If you haven't used Git before, GitHub has a tutorial [here](https://docs.github.com/en/get-started/getting-started-with-git).
The general workflow is
1. `git pull` (to get the most recent code from GitHub)
2. Write code
3. `git add .` (to add code to the repo)
4. `git commit -m "Short and descriptive message"`
5. `git push` (to send your code to GitHub)

Please be sure to work in your own branch (`git branch <name>` and then `git checkout <branch name>`) unless otherwise working with someone else.
  
1. Linking Accounts
    1. Sign in to your Robojackets Account: [my.robojackets.org](my.robotjackets.org)
    2. Click your name in the top right, click "Profile," scroll down to "Linked Accounts" and link your GitHub and Google account
    
2. Update Identity: [Guide](https://docs.github.com/en/get-started/quickstart/set-up-git)
    1. If you do not have Git installed on your computer, install it from [here](https://git-scm.com/downloads) or with your OS's package manager.

3. Generate a Personal Access Token (PAT) if needed (Make sure to not lose): 
    [Guide](https://docs.github.com/en/authentication/keeping-your-account-and-data-secure/creating-a-personal-access-token)
    1. If you know how to use SSH keys, you may also use those.

4. Download the Github Desktop App (Optional): [Download](https://desktop.github.com/)

5. Clone the robowrestling-software repository using `git clone <url>`: [repo](https://github.com/RoboJackets/robowrestling-software)

## C++ Intro

If you haven't used C++ or Arduino before, don't worry.
There are lots of tutorials on the internet and you can ask the Software STL or other teammates for help.

Here are some basic things to get you started with both C++ and Arduino.

```cpp
// file: main.cpp

#include <Arduino.h>  // adds the Arduino library
// May have other #include statements here to add other things
// For example, if you have classes for things

// Example pins
// #define <name> <value> basically makes an alias
#define LEFT_MOTOR_OUT_PIN 1
#define RIGHT_MOTOR_OUT_PIN 2
#define LIDAR_IN_PIN 3

// Setup function that runs once when the robot first starts up
// Put stuff here for setup, e.g. starting Serial connections and
// setting up pins
void setup() {
    pinMode(LIDAR_IN_PIN, INPUT);  // see how the #define'd LIDAR_IN_PIN is used here?
    pinMode(LEFT_MOTOR_OUT_PIN, OUTPUT);
    pinMode(RIGHT_MOTOR_OUT_PIN, OUTPUT);
}

// This function runs *after* the setup function does and will constantly loop
// while the bot runs
void loop() {
    // This is example code and may not work in an actual bot
    // Highly depends on your hardware
    
    // This code will do the following:
    // If the LIDAR_IN_PIN reads a 1 (sees something), then run the motors at 100%
    // Otherwise, turn in place and check again later if the lidar sees something
    if (digitalRead(LIDAR_IN_PIN) == 1) {
        analogWrite(LEFT_MOTOR_OUT_PIN, 100);
        analogWrite(RIGHT_MOTOR_OUT_PIN, 100);
    } else {
        analogWrite(LEFT_MOTOR_OUT_PIN, -100);
        analogWrite(RIGHT_MOTOR_OUT_PIN, 100);
    }
}
```

## Useful Resources

1. Competition Rules: [All Japan Sumo](https://www.fsi.co.jp/sumo/robot/en/rule.html)
2. Arduino Code Library Documentation: [Reference Page](https://www.arduino.cc/reference/en/)
3. Serial Communication: [Teensy Website](https://www.pjrc.com/teensy/td_uart.html)
4. Teensy 4.1 Documentation (newer bots): [Teensy 4.1](https://www.pjrc.com/store/teensy41.html)
4. Teensy 3.6 Documentation (Kirbi): [Teensy 3.6](https://www.pjrc.com/store/teensy36.html)
5. Teensy Pinout: [Google Drive](https://drive.google.com/drive/folders/1ci8a4ckSqtLVcKN8qR22PUycx4mC5XRj)

## EAGLE design discontinued/ControlBoard/Kirbi/v2 pcb/Kirbi_ControlBoard.brd

File discontinued/ControlBoard/README.md:

# Control Board
Does brain stuff or something, controls all sensors and motors.

## Current Supported Versions
Gucci - v3
Kirbi - v2
Spici - v2

## TODO:
Convert to KiCAD
Make new design

Parts:
5V: 5V; LED-0603
C1, C2, C3, C4, C5, C6, C9, C10, C11, C12, C14, C15, C17, C18, C25: 0.1uF; 0603
C7: 10uF; 0603
C8: 1uF; 0603
C19, C20: 15pF; 0603
C21, C22, C23, C24: 4.7uF; 0603
D1, D5: 30; DFLS130L-7
D2: 5V; LED-0603
D3: 3.3V; LED-0603
D4: 1.8V; LED-0603
DIST_1, DIST_2, DIST_3, DIST_4, DIST_5, DIST_6: 0532610471
ESC: 0532610371
F1: 3.5; C1F
JP1: PINHD-1X1; 1X01
LED1: WS2812B5050; WS2812B
LINE_LF: 75869-130LF
LINE_RF: 75869-130LF
MUX_RX1, MUX_RX2: 74LVC1G157GW,125; TSSOP6
MUX_TX1, MUX_TX2: 74LVC1G157GW,125; TSSOP6
POWER_CONN: 1719770002
POWER_SWITCH: GPTS202312B
R1, R19: 200; 0603
R2: 6.2; 0603
R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R18, R24, R25: 1k; 0603
R13: 200k; 0603
R14, R15, R16, R17: 10k; 0603
R20: 100; 0603
START: 75869-130LF
U1: TEENSY_3.6
U2: ICM-20948; 24-QFN_(3X3)
U3: PCA9306; 8-LSSOP
U4: RFM69HCW_SMT; RFMHCW_SMT
U5: LM393ADR; 8-SOIC
U6: AP2114H-1.8TRG1; SOT-223
U7: AP2114H-3.3TRG1; SOT-223

Connections:
1.8V: C1.1, C2.1, C21.1, D4.A, D5.1 (A), R14.2, R15.2, U2.8 (VDDIO), U2.13 (VDD), U2.22 (NCS), U3.2 (VREF1), U6.2 (VOUT), U6.4 (EPAD)
+3.3V: C4.1, C14.1, C17.1, C18.1, C22.1, C23.1, D1.1 (A), D3.A, D5.2 (C), LINE_LF.1, LINE_RF.1, MUX_RX1.5 (V), MUX_RX2.5 (V), MUX_TX1.5 (V), MUX_TX2.5 (V), R3.2, R4.2, R5.2, R6.2, R7.2, R10.2, R11.2, R13.2, R16.2, R17.2, R24.2, R25.2, START.3, U4.5P (VDD), U6.3 (VIN), U7.2 (VOUT), U7.4 (EPAD)
+5V: 5V.A, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C15.1, C24.1, C25.1, D1.2 (C), D2.A, DIST_1.6 (4), DIST_2.6 (4), DIST_3.6 (4), DIST_4.6 (4), DIST_5.6 (4), DIST_6.6 (4), LED1.1-VDD (VDD), POWER_SWITCH.P (COMMON), U1.VIN, U5.8 (V+), U7.3 (VIN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C15.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, DIST_1.3 (1), DIST_2.3 (1), DIST_3.3 (1), DIST_4.3 (1), DIST_5.3 (1), DIST_6.3 (1), ESC.3 (1), LED1.3-GND (GND), LINE_LF.3, LINE_RF.3, MUX_RX1.2 (GND), MUX_RX2.2 (GND), MUX_TX1.2 (GND), MUX_TX2.2 (GND), POWER_CONN.1, R1.1, R2.2, R8.1, R9.1, R12.1, R18.1, R19.2, R20.2, START.2, U1.AGND, U1.GND, U1.GND1 (GND), U2.9 (AD0/SDO), U2.11 (FSYNC), U2.18 (GND), U2.20 (RESV_20), U3.1 (GND), U4.2P (GND), U4.9P (GND), U4.16P (GND), U5.4 (V-), U6.1 (GND), U7.1 (GND)
LF_INT: C19.1, R24.1, U1.15/A1 (15/A1/T), U5.7 (OUTB)
LINE_LF: LINE_LF.2, U1.35/A16 (35/A16/PWM), U5.5 (INB+)
LINE_REF: U1.A22 (A22/DAC1), U5.2 (INA-), U5.6 (INB-)
LINE_RF: LINE_RF.2, U1.23/A9 (23/A9/T/PWM), U5.3 (INA+)
MISO: U1.12 (12/MISO0), U4.10P (MISO); also elsewhere on the board
MOSI: U1.11 (11/MOSI0), U4.11P (MOSI); also elsewhere on the board
MUXS1: MUX_RX1.6 (S), MUX_TX1.6 (S), R8.2, R12.2, U1.2 (2/PWM)
MUXS2: MUX_RX2.6 (S), MUX_TX2.6 (S), R9.2, R18.2, U1.25
unnamed: D2.C, R19.1
unnamed: D3.C, R20.1
unnamed: C3.1, U2.10 (REGOUT)
unnamed: R13.1, U3.7 (VREF2), U3.8 (EN)
unnamed: JP1.1, U4.1P (ANT)
unnamed: F1.2, POWER_SWITCH.1 (B)
unnamed: F1.1, POWER_CONN.2
unnamed: 5V.C, R1.2
unnamed: D4.C, R2.1
NEO_DI: LED1.4-DIN (DI), U1.6 (6/PWM)
PDB_!CS!: U1.17/A3 (17/A3/T/PWM); also elsewhere on the board
PDB_!EOC!: U1.18/A4 (18/A4/T/SDA0); also elsewhere on the board
PDB_START: U1.19/A5 (19/A5/T/SCL0); also elsewhere on the board
RADIO_DIO0: U1.22/A8 (22/A8/T/PWM), U4.6P (DIO0)
RADIO_NSS: R4.1, U1.30 (30/T/PWM), U4.13P (NSS)
RADIO_RESET: U1.29 (29/T/PWM), U4.14P (RESET)
RF_INT: C20.1, R25.1, U1.16/A2 (16/A2/T/PWM), U5.1 (OUTA)
RXD1: DIST_1.4 (2), MUX_RX1.3 (I0)
RXD2: DIST_2.4 (2), MUX_RX1.1 (I1)
RXD3: DIST_3.4 (2), U1.0 (0/RX1/MOSI1/T)
RXD4: DIST_4.4 (2), U1.31/A12 (31/A12/RX4)
RXD5: DIST_5.4 (2), MUX_RX2.3 (I0)
RXD6: DIST_6.4 (2), MUX_RX2.1 (I1)
S1/TRX: ESC.2, U1.34/A15 (34/A15/RX5/CAN1-RX)
S1/TTX: ESC.1 (3), U1.33/A14 (33/A14/TX5/CAN1-TX)
SCK: U1.13 (13/SCK0/LED), U4.12P (SCK); also elsewhere on the board
SCL1: R14.1, U2.23 (SCL/SCLK), U3.3 (SCL1)
SCL2: R16.1, U1.3 (3/CAN0-TX/SCL2/PWM), U3.6 (SCL2)
SDA1: R15.1, U2.24 (SDA/SDI), U3.4 (SDA1)
SDA2: R17.1, U1.4 (4/CAN0-RX/SDA2/PWM), U3.5 (SDA2)
START: START.1, U1.14/A0 (14/A0/PWM)
TRX1: MUX_RX1.4 (Y), R10.1, U1.7 (7/RX3/PWM)
TRX2: MUX_RX2.4 (Y), R11.1, U1.9 (9/RX2/PWM)
TTX1: MUX_TX1.4 (Y), U1.8 (8/TX3/PWM)
TTX2: MUX_TX2.4 (Y), U1.10 (10/TX2/PWM)
TXD1: DIST_1.5 (3), MUX_TX1.3 (I0), R3.1
TXD2: DIST_2.5 (3), MUX_TX1.1 (I1), R5.1
TXD3: DIST_3.5 (3), U1.1 (1/TX1/MISO1/T)
TXD4: DIST_4.5 (3), U1.32/A13 (32/A13/TX4)
TXD5: DIST_5.5 (3), MUX_TX2.3 (I0), R6.1
TXD6: DIST_6.5 (3), MUX_TX2.1 (I1), R7.1

Notes on the sheet:
Teensy 3.6 Pinout
Lidar Connectors
Multiplexers
Line Sensors
Start Module Connector
Miscellaneous
IMU
Voltage Regulators
Radio Transceiver
ESC Connector
Power Input
*Note: The TX and RX labels refer to the respective Teensy connection (not the sensor pins)

Parts:
PDB_CONN: 71600-006LF; AMPHENOL_2X3_2.54MM

Connections:
MISO: PDB_CONN.5 (3); also elsewhere on the board
MOSI: PDB_CONN.4 (5); also elsewhere on the board
PDB_!CS!: PDB_CONN.6 (1); also elsewhere on the board
PDB_!EOC!: PDB_CONN.2 (4); also elsewhere on the board
PDB_START: PDB_CONN.1 (6); also elsewhere on the board
SCK: PDB_CONN.3 (2); also elsewhere on the board

Board: 4 copper layers, 66.0 x 56.0 mm, 81 parts (17 on the bottom side), 53 nets.

Other parts of the board:
U$1: ROBOJACKETS
U$3, U$4: ROBOBUZZ_0.4X

## EAGLE design ControlBoard/Gucci/v1 pcbs/GucciAux.brd

Parts:
C1, C2, C3, C4, C5: 0.1uF; 0603
C6: 1.0uF; 0603
FL: PINHD-1X3; 1X03
FR: PINHD-1X3; 1X03
TOF1, TOF2, TOF3, TOF4, TOF5, TOF6: PINHD-1X5; 1X05
X1: HEADER_POS12_43045-1212; 43045-1212

Connections:
FL: FL.2, X1.P$5 (5)
FR: FR.2, X1.P$11 (11)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, FL.1, FR.3, TOF1.2, TOF2.2, TOF3.2, TOF4.2, TOF5.2, TOF6.2, X1.P$4 (4)
SCL: TOF1.4, TOF2.4, TOF3.4, TOF4.4, TOF5.4, TOF6.4, X1.P$7 (7)
SDA: TOF1.5, TOF2.5, TOF3.5, TOF4.5, TOF5.5, TOF6.5, X1.P$1 (1)
SHDN1: TOF1.3, X1.P$6 (6)
SHDN2: TOF2.3, X1.P$12 (12)
SHDN3: TOF3.3, X1.P$10 (10)
SHDN4: TOF4.3, X1.P$2 (2)
SHDN5: TOF5.3, X1.P$8 (8)
SHDN6: TOF6.3, X1.P$9 (9)
VCC: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, FL.3, FR.1, TOF1.1, TOF2.1, TOF3.1, TOF4.1, TOF5.1, TOF6.1, X1.P$3 (3)

Notes on the sheet:
Main Board Bus
Time Of Flight Sensors
Decoupling Caps
Line Sensors

Board: 2 copper layers, 47.0 x 37.5 mm, 19 parts (0 on the bottom side), 12 nets.

Other parts of the board:
U$1, U$2: ROBOBUZZ_0.4X
U$3, U$4: 2,8

## EAGLE design PowerDistribution/powerDistribution.brd

Parts:
+3.3V, +5V, +24V: Green; CHIP-LED0603
C1, C2, C5, C6: 0.1uF; C0603
C3, C4: 1000pF; C0603
C7, C10: 180uF; 860010373009
C8, C9: 4.7uF; C0603
C11, C13, C14: 15uF; TR3E156M050C0300
C12: 0.47uF; C0603
C15: 100nF; C0603
D1: SD2114S040S8R0
D2, D3: 30; DFLS130L-7
D4: TVSDIODE
F1: 5A; ERB-RE5R00V
J1: XT-60BATT_LABEL; XT-60
J2, J3: CONNECTORESC_CONNECTOR; ESC_CONNECT
J4: MOLEX_2.54MM_2PIN
J5: AMPHENOL_2X3_2.54MM
L1: 22uH; INDUCTOR22
R1, R2, R9, R13: 20k; R0603
R3, R10, R14: 100; R0603
R4: 200; R0603
R5: 1200; R0603
R6: 1k; R0603
R7, R8, R11, R12: 39k; R0603
U1: MAX11635EEE+; 21-0055H_16_MXM
U2: LM2678SX-5.0/NOPB; TS7B
U3, U4: CQ2065; 974-1092-1
U7: AP2114H-3.3TRG1; SOT-223
XF1, XF2: 40A; 3550

Connections:
!CS!: J5.4 (5), R6.1, U1.12 (!CS)
!EOC!: J5.2 (4), U1.16 (!EOC)
!START!: J5.3 (2), U1.8 (!CNVST)
+3V3: C6.1, C9.1, D3.1 (A), R3.2, R6.2, U1.11 (VDD), U7.2 (VOUT), U7.4 (EPAD)
+5V: C1.1, C2.1, C8.1, D2.1 (A), D3.2 (C), F1.2, J4.1, R4.2, R9.2, R13.2, U3.2 (VDD), U4.2 (VDD), U7.3 (VIN)
+24V: C11.1 (+), C12.1, C13.1 (+), C14.1 (+), D2.2 (C), D4.P$2 (C), J1.BATT (1), R5.2, U2.2 (VIN), XF1.3 (2), XF1.4 (2), XF2.1, XF2.2 (1)
GND: +3.3V.C (K), +5V.C (K), +24V.C (K), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2 (-), C8.2, C9.2, C10.2 (-), C11.2 (-), C12.2, C13.2 (-), C14.2 (-), D1.1 (A), D4.P$1 (A), J1.GND (2), J2.GND (2), J3.GND (2), J4.2, R7.1, R8.2, R11.1, R12.2, U1.3 (AIN2), U1.4 (AIN3), U1.7 (REF-), U1.10 (GND), U2.4 (GND), U2.8 (GND), U3.1 (DATA_IO), U3.3 (VSS), U3.5 (SCLK), U4.1 (DATA_IO), U4.3 (VSS), U4.5 (SCLK), U7.1 (GND)
I1: U3.6 (I_P), XF1.1, XF1.2 (1)
I2: U4.7 (I_N), XF2.3 (2), XF2.4 (2)
L_ESC: J2.ESC (1), U3.7 (I_N)
L_MOTOR: C3.1, R10.1, U1.1 (AIN0)
MISO: J5.1 (6), U1.15 (DOUT)
MOSI: J5.6 (1), U1.14 (DIN)
unnamed: R1.1, U4.4 (VOUT)
unnamed: R2.2, R7.2, R10.2
unnamed: R2.1, U3.4 (VOUT)
unnamed: R1.2, R11.2, R14.2
unnamed: +3.3V.A, R3.1
unnamed: C15.2, D1.2 (C), L1.1, U2.1 (SW)
unnamed: C15.1, U2.3 (CB)
unnamed: +5V.A, R4.1
unnamed: +24V.A, R5.1
unnamed: C7.1 (+), C10.1 (+), F1.1, L1.2, U2.6 (FB)
R_ESC: J3.ESC (1), U4.6 (I_P)
R_MOTOR: C4.1, R14.1, U1.2 (AIN1)
SCLK: J5.5 (3), U1.13 (SCLK)
VREF: C5.1, R8.1, R9.1, R12.1, R13.1, U1.9 (REF+)

Notes on the sheet:
Hall Effect Current Sensors
12-bit ADC
TEENSY Connector
Voltage Regulators
Motor & Battery Connector
Status LEDs
0.1%

Board: 2 copper layers, 79.8 x 81.8 mm, 54 parts (0 on the bottom side), 27 nets.

Other parts of the board:
U$1: ROBOJACKETS
U$2: ROBOBUZZ_0.2X
U$4: ROBOBUZZ_0.4X
U$5: ROBOBUZZ_0.6X

## EAGLE design Radio/Radii.brd

Parts:
C1, C2, C3, C6, C9, C10, C11, C15, C16, C17, C18, C19, C20: 0.1uF; 0603
C4: 1.0uF; 0603
C5: 10uF; 0603
C7, C8: 22uF; 1210
C12: 10nF; 0603
C13, C14: 33pF; 0603
D1, D2: GREEN; CHIP-LED0603
J1: 10118193-0001LF; FCI_10118193-0001LF
J2, J3, J4, J5, J6: BUTTON; 1X02
J7: S2B-PH-SM4-TB(LF)(SN); JST_S2B-PH-SM4-TB(LF)(SN)
JP1: PINHD-1X7; 1X07
JP2: PINHD-1X1; 1X01
Q1: PMOS; SOT-23-3
R1, R2: 22Ω; 0603-RES
R3, R4: 0603
R5, R6, R8, R10, R11, R13, R15, R17: 10K; 0603-RES
R7, R9, R12, R14, R16: 1K; 0603-RES
S1: KMR2
U1: RFM69HCW_SMT; RFMHCW_SMT
U2: ATMEGA32U4-AU; 44-TQFP(10X10)
U3: AP63203WU-7; TSOT-23-6
U4: 3.9uH; 1255AY-3R9N=P3
Y1: 8.000 MHz; XTAL_ECS-80-20-5PX-TR

Connections:
3.3V: C1.1, C2.1, C3.1, C4.1, C7.1, C8.1, C9.1, C10.1, C11.1, D2.A, J2.1, J3.1, J4.1, J5.1, J6.1, JP1.1, R10.1, R11.2, R17.2, U1.5P (VDD), U2.6 (UCAP), U2.14 (VCC), U2.24 (AVCC), U2.34 (VCC), U2.44 (AVCC), U3.1 (FB), U4.2
9V: C5.1, D1.A, Q1.2 (S), U3.2 (EN), U3.3 (VIN)
BUTTON1: C17.1, R7.1, U2.20 (PD2(RXD1/INT2))
BUTTON2: C16.1, R12.1, U2.21 (PD3(TXD1/INT3))
BUTTON3: C19.1, R14.1, U2.25 (PD4(ICP1/ADC8))
BUTTON4: C18.1, R9.1, U2.22 (PD5(XCK1/!CTS!))
BUTTON5: C20.1, R16.1, U2.27 (PD7(T0/OC4D/ADC10))
CS: JP1.5, R17.1, U2.30 (PB6(PCINT6/OC1B/OC4B/ADC))
DC_SELECT: JP1.7, U2.28 (PB4(PCINT4/ADC11))
DIFF1_N: R1.2, U2.3 (D-)
DIFF1_P: R2.2, U2.4 (D+)
DIFF_N: J1.2 (D-), R1.1
DIFF_P: J1.3 (D+), R2.1
DISP_RESET: JP1.6, U2.29 (PB5(PCINT5/OC1A/OC4B/ADC))
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, J1.5 (GND), J1.S1 (SHIELD), J1.S2 (SHIELD), J1.S3 (SHIELD), J1.S4 (SHIELD), J1.S5 (SHIELD), J1.S6 (SHIELD), J7.2, J7.S1 (SHIELD), J7.S2 (SHIELD), JP1.2, Q1.1 (G), R3.2, R4.2, R5.1, R6.1, R8.1, R13.1, R15.1, S1.2.1 (2), S1.2.2 (2), U1.2P (GND), U1.9P (GND), U1.16P (GND), U2.5 (UGND), U2.15 (GND), U2.23 (GND), U2.35 (GND), U2.43 (GND), U3.4 (GND)
INT: U1.6P (DIO0), U2.36 (PF7(ADC7/TDI))
MISO: U1.10P (MISO), U2.11 (PB3(PDO/PCINT3/MISO))
MOSI: JP1.4, U1.11P (MOSI), U2.10 (PB2(PDI/PCINT2/MOSI))
unnamed: C6.2, U3.5 (SW), U4.1
unnamed: C6.1, U3.6 (BST)
unnamed: JP2.1, U1.1P (ANT)
unnamed: J3.2, R6.2, R7.2
unnamed: C13.1, U2.16 (XTAL2), Y1.2
unnamed: C12.1, U2.42 (AREF)
unnamed: C14.1, U2.17 (XTAL1), Y1.1
unnamed: D1.C (K), R3.1
unnamed: D2.C (K), R4.1
unnamed: J2.2, R5.2, R12.2
unnamed: J4.2, R8.2, R9.2
unnamed: J5.2, R13.2, R14.2
unnamed: J6.2, R15.2, R16.2
unnamed: C15.1, R10.2, S1.1.1 (1), S1.1.2 (1), U2.13 (!RESET)
RADIO_RESET: U1.14P (RESET), U2.37 (PF6(ADC6/TDO))
SCK: JP1.3, U1.12P (SCK), U2.9 (PB1(PCINT1/SCLK))
SS: R11.1, U1.13P (NSS), U2.38 (PF5(ADC5/TMS))
VCC: J7.1, Q1.3 (D)
VUSB: J1.1 (VUSB), U2.7 (VBUS)

Notes on the sheet:
Power
MCU Pinout
Radio Module
LCD Display
Radio Debugging Device for Sumo Bot
RoboWrestling
USB Connector
Buttons

Board: 2 copper layers, 42.6 x 44.9 mm, 57 parts (2 on the bottom side), 37 nets.

Other parts of the board:
U$1: ROBOBUZZ_0.8X
U$2: ROBOJACKETS

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
