# Repository RoboJackets/robowrestling-software (continued)

## EAGLE design Kirbi/v1 pcb/Kirbi_ControlBoard.brd

Board: 2 copper layers, 66.0 x 56.0 mm, 86 parts (2 on the bottom side), 55 nets.

Parts:
BATT: TE_02X01_3.96MM
C1, C2, C3, C4, C5, C6, C9, C10, C11, C12, C13, C14, C17, C18: 0.1uF; 0603
C7, C15: 10uF; 0603
C8, C16: 1uF; 0603
C19, C20: 15pF; 0603
C21, C22, C23, C24: 4.7uF; 0603
D1: 24V; LED-0603
D2: 5V; LED-0603
D3: 3.3V; LED-0603
D4: 1.8V; LED-0603
DIST_1, DIST_2, DIST_3, DIST_4: AMPHENOL_2X02_2.54MM_SHROUD
ESC: MOLEX_1.25MM_4PIN_90
IMU: ICM-20948; QFN40P300X300X105-25N
LIDAR_L: MOLEX_1.25MM_4PIN_90
LIDAR_R: MOLEX_1.25MM_4PIN_90
LINE_LF: AMPHENOL_2X02_2.54MM_SHROUD
LINE_RF: AMPHENOL_2X02_2.54MM_SHROUD
L_ENC: 2X05/90
L_MOT: 1X02
R1, R3, R5, R7, R9, R11: 2k; 0603
R2, R4, R6, R8, R10, R12: 3k; 0603
R13: 200k; 0603
R14, R15, R16, R17: 10k; 0603
R18: 11.15k; 0603
R19: 1.65k; 0603
R20: 800; 0603
R21: 50; 0603
R22, R26, R28, R30: 6.98k; 0603
R23, R24, R25, R27, R29, R31: 1k; 0603
R_ENC: 2X05/90
R_MOT: 1X02
START: AMPHENOL_2X02_2.54MM_SHROUD
U1: PCA9306_LSSOP; 8-LSSOP
U2: TEENSY_3.6_DIL
U3, U4: MAX4173-SOT-23; SOT-23
U5: LM393-8-SOIC; 8-SOIC
U6: AP2114H-1.8TRG1; SOT-223
U7: AP2114H-3.3TRG1; SOT-223
U$1: ROBOJACKETS
U$2: ROBOBUZZ_1.4X
U$3, U$4: ROBOBUZZ_0.4X

Connections:
1.8V: C1.1, C2.1, C21.1, D4.A, IMU.8, IMU.13, IMU.22, R14.2, R15.2, U1.P$2, U6.2, U6.4
3V_ENCODER1_A: R5.2, R6.2, U2.22/A8
3V_ENCODER1_B: R3.2, R4.2, U2.21/A7
3V_ENCODER1_I: R1.2, R2.2, U2.20/A6
3V_ENCODER2_A: R11.2, R12.2, U2.38/A19
3V_ENCODER2_B: R9.2, R10.2, U2.37/A18
3V_ENCODER2_I: R7.2, R8.2, U2.36/A17
5V: C6.1, C7.1, C8.1, C11.1, C12.1, C13.1, C24.1, D2.A, ESC.P$3, LIDAR_L.P$1, LIDAR_R.P$1, L_ENC.2, R_ENC.2, U2.VIN, U5.P$8, U7.3
24V: BATT.P$1, C4.1, C5.1, C9.1, C10.1, C15.1, C16.1, D1.A, DIST_1.2, DIST_1.4, DIST_2.2, DIST_2.4, DIST_3.2, DIST_3.4, DIST_4.2, DIST_4.4
+3.3V: C14.1, C17.1, C18.1, C22.1, C23.1, D3.A, LINE_LF.1, LINE_RF.1, R13.2, R16.2, R17.2, R24.2, R25.2, START.3, U3.P$3, U4.P$3, U6.3, U7.2, U7.4
CURRENT_L: U2.A21, U4.P$6
CURRENT_R: U2.14/A0, U3.P$6
DIST_L: R22.1, R23.2, U2.30
DIST_L_45: R26.1, R27.2, U2.28
DIST_R: R28.1, R29.2, U2.2
DIST_R_45: R30.1, R31.2, U2.3
ENCODER1_A: R5.1, R_ENC.6
ENCODER1_B: R3.1, R_ENC.8
ENCODER2_A: L_ENC.6, R11.1
ENCODER2_B: L_ENC.8, R9.1
GND: BATT.P$2, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, DIST_1.1, DIST_2.1, DIST_3.1, DIST_4.1, ESC.P$4, IMU.11, IMU.18, IMU.20, LIDAR_L.P$4, LIDAR_R.P$4, LINE_LF.3, LINE_RF.3, L_ENC.3, R2.1, R4.1, R6.1, R8.1, R10.1, R12.1, R18.2, R19.2, R20.2, R21.2, R23.1, R27.1, R29.1, R31.1, R_ENC.3, START.2, U1.P$1, U2.AGND, U2.GND, U2.GND1, U3.P$1, U3.P$2, U4.P$1, U4.P$2, U5.P$4, U6.1, U7.1
IMU_AD0: IMU.9, U2.9
IMU_INT: IMU.12, U2.12
LF_INT: C19.1, R24.1, U2.18/A4, U5.P$7
LINE_LF: LINE_LF.2, U2.35/A16, U5.P$5
LINE_REF: U2.A22, U5.P$2, U5.P$6
LINE_RF: LINE_RF.2, U2.23/A9, U5.P$3
L_MOT+: L_MOT.2, U4.P$4
L_MOT-: L_MOT.1, U4.P$5
unnamed: D2.C, R19.1
unnamed: D3.C, R20.1
unnamed: C3.1, IMU.10
unnamed: R13.1, U1.P$7, U1.P$8
unnamed: R1.1, R_ENC.10
unnamed: D1.C, R18.1
unnamed: DIST_1.3, R28.2
unnamed: L_ENC.10, R7.1
unnamed: DIST_4.3, R22.2
unnamed: D4.C, R21.1
unnamed: DIST_3.3, R26.2
unnamed: DIST_2.3, R30.2
RF_INT: C20.1, R25.1, U2.19/A5, U5.P$1
RX1: LIDAR_R.P$3, U2.0
RX2: LIDAR_L.P$3, U2.31/A12
R_MOT+: R_MOT.2, U3.P$4
R_MOT-: R_MOT.1, U3.P$5
S1/TX: ESC.P$2, U2.33/A14
S2: ESC.P$1, U2.34/A15
SCL1: IMU.23, R14.1, U1.P$3
SCL2: R16.1, U1.P$6, U2.7
SDA1: IMU.24, R15.1, U1.P$4
SDA2: R17.1, U1.P$5, U2.8
START: START.1, U2.17/A3
TX1: LIDAR_R.P$2, U2.1
TX2: LIDAR_L.P$2, U2.32/A13

## EAGLE design Gucci/v4 pcb/Gucci_ControlBoard.brd

File Gucci/README.md:

# Gucci repository contents: <br/> <br/>
**drc**: used design rule check files <br/>
**libraries**: used EAGLE libraries <br/>
**vX board**: contains .brd, .sch, and gerber .zip files <br/>

Parts:
C1, C2, C3, C4, C5, C6, C9, C10, C11, C12, C14, C15, C17, C18, C25: 0.1uF; 0603
C7: 10uF; 0603
C8: 1uF; 0603
C19, C20: 15pF; 0603
C21, C22, C23, C24: 4.7uF; 0603
D2: 5V; LED-0603
D3: 3.3V; LED-0603
D4: 1.8V; LED-0603
DIST_1, DIST_2, DIST_3, DIST_4, DIST_5, DIST_6: MOLEX_1.25MM_4PIN_SMT
ESC1, ESC2: MOLEX_1.25MM_3PIN_SMT
ESC_RX: MUX_74LVC1G157GV
ESC_TX: MUX_74LVC1G157GV
F1: 3.5; BEL_FUSE_C1F_3.5
IMU: ICM-20948; QFN40P300X300X105-25N
JP1: PINHD-1X1; 1X01
LED1: WS2812B5050; WS2812B
LINE_LF: AMPHENOL_2X02_2.54MM_SHROUD
LINE_RF: AMPHENOL_2X02_2.54MM_SHROUD
MUX_RX1, MUX_RX2: MUX_74LVC1G157GV
MUX_TX1, MUX_TX2: MUX_74LVC1G157GV
POWER: POWER_SWITCH; ELUMEESAQ7C12
POWER_CONN: MOLEX_2.54MM_2PIN
R1, R20: 100; 0603
R2: 6.2; 0603
R3, R4, R5, R24, R25: 1k; 0603
R13: 200k; 0603
R14, R15, R16, R17: 10k; 0603
R19: 200; 0603
START: AMPHENOL_2X02_2.54MM_SHROUD
TRANSCEIVER: RFM69HCW_SMT; RFMHCW_SMT
U1: PCA9306_LSSOP; 8-LSSOP
U2: TEENSY_3.6_DIL
U5: LM393-8-SOIC; 8-SOIC
U6: AP2114H-1.8TRG1; SOT-223
U7: AP2114H-3.3TRG1; SOT-223

Connections:
1.8V: C1.1, C2.1, C21.1, D4.A, IMU.8 (VDDIO), IMU.13 (VDD), IMU.22 (NCS), R14.2, R15.2, U1.P$2 (VREF1), U6.2 (VOUT), U6.4 (EPAD)
+3.3V: C4.1, C14.1, C17.1, C18.1, C22.1, C23.1, D3.A, ESC_RX.P$5 (V), ESC_TX.P$5 (V), LINE_LF.1, LINE_RF.1, MUX_RX1.P$5 (V), MUX_RX2.P$5 (V), MUX_TX1.P$5 (V), MUX_TX2.P$5 (V), R3.2, R4.2, R5.2, R13.2, R16.2, R17.2, R24.2, R25.2, START.3, TRANSCEIVER.5P (VDD), U6.3 (VIN), U7.2 (VOUT), U7.4 (EPAD)
+5V: C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C15.1, C24.1, C25.1, D2.A, DIST_1.P$6 (4), DIST_2.P$6 (4), DIST_3.P$6 (4), DIST_4.P$6 (4), DIST_5.P$6 (4), DIST_6.P$6 (4), LED1.1-VDD (VDD), POWER.P3, POWER.P5, U2.VIN, U5.P$8 (VCC), U7.3 (VIN)
ESC_S: ESC_RX.P$6 (S), ESC_TX.P$6 (S), U2.36/A17 (36/A17/PWM)
ESC_TRX: ESC_RX.P$4 (Y), R5.1, U2.34/A15 (34/A15/RX5/CAN1-RX)
ESC_TTX: ESC_TX.P$4 (Y), U2.33/A14 (33/A14/TX5/CAN1-TX)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C14.2, C15.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, DIST_1.P$3 (1), DIST_2.P$3 (1), DIST_3.P$3 (1), DIST_4.P$3 (1), DIST_5.P$3 (1), DIST_6.P$3 (1), ESC1.P$3 (1), ESC2.P$3 (1), ESC_RX.P$2 (GND), ESC_TX.P$2 (GND), IMU.9 (AD0/SDO), IMU.11 (FSYNC), IMU.18 (GND), IMU.20 (RESV_20), LED1.3-GND (GND), LINE_LF.3, LINE_RF.3, MUX_RX1.P$2 (GND), MUX_RX2.P$2 (GND), MUX_TX1.P$2 (GND), MUX_TX2.P$2 (GND), POWER_CONN.P$2, R1.1, R2.2, R19.2, R20.2, START.2, TRANSCEIVER.2P (GND), TRANSCEIVER.9P (GND), TRANSCEIVER.16P (GND), U1.P$1 (GND), U2.AGND, U2.GND, U2.GND1 (GND), U5.P$4 (GND), U6.1 (GND), U7.1 (GND)
LF_INT: C19.1, R24.1, U2.15/A1 (15/A1/T), U5.P$7 (OUT2)
LINE_LF: LINE_LF.2, U2.35/A16 (35/A16/PWM), U5.P$5 (IN2+)
LINE_REF: U2.A22 (A22/DAC1), U5.P$2 (IN1-), U5.P$6 (IN2-)
LINE_RF: LINE_RF.2, U2.23/A9 (23/A9/T/PWM), U5.P$3 (IN1+)
MISO: TRANSCEIVER.10P (MISO), U2.12 (12/MISO0)
MOSI: TRANSCEIVER.11P (MOSI), U2.11 (11/MOSI0)
MUXS1: MUX_RX1.P$6 (S), MUX_TX1.P$6 (S), U2.2 (2/PWM)
MUXS2: MUX_RX2.P$6 (S), MUX_TX2.P$6 (S), U2.25
unnamed: D2.C, R19.1
unnamed: D3.C, R20.1
unnamed: C3.1, IMU.10 (REGOUT)
unnamed: R13.1, U1.P$7 (VREF2), U1.P$8 (EN)
unnamed: JP1.1, TRANSCEIVER.1P (ANT)
unnamed: F1.P$2, POWER.P4
unnamed: F1.P$1, POWER_CONN.P$1
unnamed: POWER.P1, R1.2
unnamed: D4.C, R2.1
NEO_DI: LED1.4-DIN (DI), U2.24
RADIO_DIO0: TRANSCEIVER.6P (DIO0), U2.5 (5/PWM)
RADIO_NSS: TRANSCEIVER.13P (NSS), U2.30 (30/T/PWM)
RADIO_RESET: TRANSCEIVER.14P (RESET), U2.29 (29/T/PWM)
RADIO_SCK: TRANSCEIVER.12P (SCK), U2.13 (13/SCK0/LED)
RF_INT: C20.1, R25.1, U2.16/A2 (16/A2/T/PWM), U5.P$1 (OUT1)
RXD1: DIST_1.P$4 (2), MUX_RX1.P$3 (I0)
RXD2: DIST_2.P$4 (2), MUX_RX1.P$1 (I1)
RXD3: DIST_3.P$4 (2), U2.0 (0/RX1/MOSI1/T)
RXD4: DIST_4.P$4 (2), U2.31/A12 (31/A12/RX4)
RXD5: DIST_5.P$4 (2), MUX_RX2.P$3 (I0)
RXD6: DIST_6.P$4 (2), MUX_RX2.P$1 (I1)
S1/RX: ESC1.P$2 (2), ESC_RX.P$3 (I0)
S1/TX: ESC1.P$1 (3), ESC_TX.P$3 (I0)
S2/RX: ESC2.P$2 (2), ESC_RX.P$1 (I1)
S2/TX: ESC2.P$1 (3), ESC_TX.P$1 (I1)
SCL1: IMU.23 (SCL/SCLK), R14.1, U1.P$3 (SCL1)
SCL2: R16.1, U1.P$6 (SCL2), U2.3 (3/CAN0-TX/SCL2/PWM)
SDA1: IMU.24 (SDA/SDI), R15.1, U1.P$4 (SDA1)
SDA2: R17.1, U1.P$5 (SDA2), U2.4 (4/CAN0-RX/SDA2/PWM)
START: START.1, U2.14/A0 (14/A0/PWM)
TRX1: MUX_RX1.P$4 (Y), R4.1, U2.7 (7/RX3/PWM)
TRX2: MUX_RX2.P$4 (Y), R3.1, U2.9 (9/RX2/PWM)
TTX1: MUX_TX1.P$4 (Y), U2.8 (8/TX3/PWM)
TTX2: MUX_TX2.P$4 (Y), U2.10 (10/TX2/PWM)
TXD1: DIST_1.P$5 (3), MUX_TX1.P$3 (I0)
TXD2: DIST_2.P$5 (3), MUX_TX1.P$1 (I1)
TXD3: DIST_3.P$5 (3), U2.1 (1/TX1/MISO1/T)
TXD4: DIST_4.P$5 (3), U2.32/A13 (32/A13/TX4)
TXD5: DIST_5.P$5 (3), MUX_TX2.P$3 (I0)
TXD6: DIST_6.P$5 (3), MUX_TX2.P$1 (I1)

Notes on the sheet:
Teensy 3.6 Pinout
Lidar Connectors
Multiplexers
Line Sensors
Start Module Connector
Miscellaneous
IMU
Voltage Regulators
Radio Transceiver
ESC Connector
Power Input

Board: 2 copper layers, 66.0 x 56.0 mm, 72 parts (16 on the bottom side), 55 nets.

Other parts of the board:
U$1: ROBOJACKETS
U$3, U$4: ROBOBUZZ_0.4X

## EAGLE design Gucci/v2 pcb/Gucci_ControlBoard.brd

Parts:
C1, C2, C3, C4, C6, C8, C9, C10, C11, C12, C13, C14, C15, C16: 0.1uF; 0603
C5: 10uF; 0603
C17, C18: 15pF; 0603
C19, C20, C21, C22: 4.7uF; 0603
D1: 5V; LED-0603
D2: 3.3V; LED-0603
D3: 1.8V; LED-0603
ESC: MOLEX_1.25MM_4PIN_SMT
IMU: ICM-20948; QFN40P300X300X105-25N
LED1: WS2812B5050; WS2812B
LINE_LF: AMPHENOL_2X02_2.54MM_SHROUD
LINE_RF: AMPHENOL_2X02_2.54MM_SHROUD
POWER: POWER_SWITCH; ELUMEESAQ7C12
R1, R20: 50; 0603
R13: 200k; 0603
R14, R15, R16, R17: 10k; 0603
R18: 1.65k; 0603
R19: 800; 0603
R21, R22: 1k; 0603
START: AMPHENOL_2X02_2.54MM_SHROUD
TOF_1, TOF_2, TOF_3, TOF_4, TOF_5, TOF_6: AMPHENOL_2X03_2.54MM_SHROUD
TRANSCEIVER: PINHD-1X8BIG; 1X08-BIG
U1: PCA9306_LSSOP; 8-LSSOP
U2: TEENSY_3.6_DIL
U5: LM393-8-SOIC; 8-SOIC
U6: AP2114H-1.8TRG1; SOT-223
U7: AP2114H-3.3TRG1; SOT-223

Connections:
1.8V: C1.1, C2.1, C19.1, D3.A, IMU.8 (VDDIO), IMU.13 (VDD), IMU.22 (NCS), R14.2, R15.2, U1.P$2 (VREF1), U6.2 (VOUT), U6.4 (EPAD)
3.3V: C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C20.1, C21.1, D2.A, LINE_LF.1, LINE_RF.1, R13.2, R16.2, R17.2, R21.2, R22.2, START.3, TOF_1.6, TOF_2.6, TOF_3.6, TOF_4.6, TOF_5.6, TOF_6.6, U6.3 (VIN), U7.2 (VOUT), U7.4 (EPAD)
5V: C4.1, C5.1, C6.1, C22.1, D1.A, LED1.1-VDD (VDD), POWER.P3, POWER.P5, U2.VIN, U5.P$8 (VCC), U7.3 (VIN)
+3V3: TRANSCEIVER.8
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, ESC.P$3 (1), IMU.9 (AD0/SDO), IMU.11 (FSYNC), IMU.18 (GND), IMU.20 (RESV_20), LED1.3-GND (GND), LINE_LF.3, LINE_RF.3, R1.2, R18.2, R19.2, R20.2, START.2, TOF_1.5, TOF_2.5, TOF_3.5, TOF_4.5, TOF_5.5, TOF_6.5, TRANSCEIVER.7, U1.P$1 (GND), U2.AGND, U2.GND, U2.GND1 (GND), U5.P$4 (GND), U6.1 (GND), U7.1 (GND)
LF_INT: C17.1, R21.1, U2.18/A4 (18/A4/T/SDA0), U5.P$7 (OUT2)
LINE_LF: LINE_LF.2, U2.35/A16 (35/A16/PWM), U5.P$5 (IN2+)
LINE_REF: U2.A22 (A22/DAC1), U5.P$2 (IN1-), U5.P$6 (IN2-)
LINE_RF: LINE_RF.2, U2.23/A9 (23/A9/T/PWM), U5.P$3 (IN1+)
MISO: TRANSCEIVER.1, U2.12 (12/MISO0)
MOSI: TRANSCEIVER.2, U2.11 (11/MOSI0)
unnamed: D1.C, R18.1
unnamed: D2.C, R19.1
unnamed: C3.1, IMU.10 (REGOUT)
unnamed: D3.C, R20.1
unnamed: POWER.P1, R1.1
unnamed: ESC.P$6 (4), POWER.P4
unnamed: R13.1, U1.P$7 (VREF2), U1.P$8 (EN)
NEO_DI: LED1.4-DIN (DI), U2.24
NEO_DO: U2.39/A20
RADIO_DIO0: TRANSCEIVER.6, U2.14/A0 (14/A0/PWM)
RADIO_NSS: TRANSCEIVER.4, U2.10 (10/TX2/PWM)
RADIO_SCK: TRANSCEIVER.3, U2.13 (13/SCK0/LED)
RF_INT: C18.1, R22.1, U2.19/A5 (19/A5/T/SCL0), U5.P$1 (OUT1)
RX0: U2.7 (7/RX3/PWM)
RX1: U2.27
SCL0: TOF_1.2, TOF_2.2, TOF_3.2, TOF_4.2, TOF_5.2, TOF_6.2, U2.33/A14 (33/A14/TX5/CAN1-TX)
SCL1: IMU.23 (SCL/SCLK), R14.1, U1.P$3 (SCL1)
SCL2: R16.1, U1.P$6 (SCL2), U2.3 (3/CAN0-TX/SCL2/PWM)
SDA0: TOF_1.1, TOF_2.1, TOF_3.1, TOF_4.1, TOF_5.1, TOF_6.1, U2.34/A15 (34/A15/RX5/CAN1-RX)
SDA1: IMU.24 (SDA/SDI), R15.1, U1.P$4 (SDA1)
SDA2: R17.1, U1.P$5 (SDA2), U2.4 (4/CAN0-RX/SDA2/PWM)
SHDN0: TOF_1.3, U2.0 (0/RX1/MOSI1/T)
SHDN1: TOF_2.3, U2.1 (1/TX1/MISO1/T)
SHDN2: TOF_3.3, U2.2 (2/PWM)
SHDN3: TOF_4.3, U2.30 (30/T/PWM)
SHDN4: TOF_5.3, U2.31/A12 (31/A12/RX4)
SHDN5: TOF_6.3, U2.32/A13 (32/A13/TX4)
START: START.1, U2.17/A3 (17/A3/T/PWM)
TX0: U2.8 (8/TX3/PWM)
TX1: U2.26

Notes on the sheet:
Teensy 3.6 Pinout
Time of Flight Connectors
ESC Connectors
Line Sensors
Start Module Connector
Miscellaneous
IMU
Voltage Regulators
NeoPixel Status
Power

Board: 2 copper layers, 66.0 x 56.0 mm, 58 parts (10 on the bottom side), 35 nets.

Other parts of the board:
U$1: ROBOJACKETS
U$2: ROBOBUZZ_1.4X
U$3, U$4: ROBOBUZZ_0.4X

## Code that names these connections

File Diagnostic/blindspottest/blindspottest.ino:

#define TOF_L 0
#define TOF_L_45 1
#define TOF_L_C 2
#define TOF_R_C 30
#define TOF_R_45 31
#define TOF_R 32

#define LEFT_LIDAR_SERIAL Serial4
#define RIGHT_LIDAR_SERIAL Serial1
#define LEFT_LIDAR 4 // for use in read lidar methods
#define RIGHT_LIDAR 1

int dist[6];
#include <Wire.h>

int not_visible_count = 0;
int loop_count = 0;
int sensor_index = 5;
int num_iterations = 250;

#define DIST_L 30
#define DIST_L_45 28
#define DIST_R 2
#define DIST_R_45 3

#define MAX_DIST 150

byte factoryReset[4] = {0x5A, 0x04, 0x10, 0x6E};
byte saveSettings[4] = {0x5A, 0x04, 0x11, 0x6F};
byte setFramerate[6] = {0x5A, 0x06, 0x03, 0x00, 0xF0, 0xD3}; //index 3 and 4 set the frame rate to 1000/x where x is 0x[4][3]
byte setBaudrate[8] = {0x5A, 0x08, 0x06,0x00, 0x50, 0x46, 0x00,0x8A}; //To change the baud you must set the baud to the current baud to communicate, write the baud and save settings, 
                                                                      //then close and reopen at the new baud. Out of box baud is 115200 for tfmini
int tim = 0;
int lasttim = 0;
void setup() {
  // put your setup code here, to run once:
    Serial.println(1);
    LEFT_LIDAR_SERIAL.setRX(31);
    LEFT_LIDAR_SERIAL.setTX(32);
    while(!LEFT_LIDAR_SERIAL){delay(10);}
//    LEFT_LIDAR_SERIAL.begin(115200);
//    LEFT_LIDAR_SERIAL.write(factoryReset, 4);
    
    LEFT_LIDAR_SERIAL.begin(4608000);
    LEFT_LIDAR_SERIAL.write(setBaudrate, 8);
    LEFT_LIDAR_SERIAL.write(saveSettings, 4);
    LEFT_LIDAR_SERIAL.end();
    LEFT_LIDAR_SERIAL.begin(2000000);
    LEFT_LIDAR_SERIAL.write(setFramerate, 6);
    LEFT_LIDAR_SERIAL.write(saveSettings, 4);
    
    
    RIGHT_LIDAR_SERIAL.setRX(0);
    RIGHT_LIDAR_SERIAL.setTX(1);
    while(!RIGHT_LIDAR_SERIAL){delay(10);}
//    RIGHT_LIDAR_SERIAL.begin(115200);
//    RIGHT_LIDAR_SERIAL.write(factoryReset, 4);

    RIGHT_LIDAR_SERIAL.begin(4608000);
    RIGHT_LIDAR_SERIAL.write(setBaudrate, 8);
    RIGHT_LIDAR_SERIAL.write(saveSettings, 4);
    RIGHT_LIDAR_SERIAL.end();
    RIGHT_LIDAR_SERIAL.begin(2000000);
    RIGHT_LIDAR_SERIAL.write(setFramerate, 6);
    RIGHT_LIDAR_SERIAL.write(saveSettings, 4);
    
    Serial.println(2);
    pinMode(DIST_L, INPUT);
    pinMode(DIST_L_45, INPUT);
    pinMode(DIST_R, INPUT);
    pinMode(DIST_R_45, INPUT);
}

void loop() {
  // put your main code here, to run repeatedly:
    dist[0] = digitalRead(DIST_L);
    dist[1] = digitalRead(DIST_L_45);
    dist[2] = digitalRead(DIST_R);
    dist[3] = digitalRead(DIST_R_45);
    dist[4] = read_lidar(LEFT_LIDAR);
    dist[5] = read_lidar(RIGHT_LIDAR);
//    Serial.print(dist[0]);
//    Serial.print(dist[1]);
//    Serial.print(dist[2]);
//    Serial.print(dist[3]);
//      Serial.println(dist[4]);
//      Serial.println(dist[5]);
//    Serial.println();
    if (dist[sensor_index] >= MAX_DIST) {
//      Serial.println(dist[sensor_index]);
      not_visible_count+=1;
    }
    loop_count += 1;
    if (loop_count == num_iterations) {
      tim = micros() - lasttim;
      lasttim = micros();
      Serial.println(String(not_visible_count / (double) num_iterations * 100) + "% missed. Time since last " + tim);
      loop_count = 0;
      not_visible_count = 0;
    } 
    
//    for (int i = sizeof(dist)/sizeof(dist[0])-1; i >= 0; i--) {
//      Serial.print(dist[i]);
//      Serial.print(" ");
//      if (dist[i] > 0 && dist[i] < 1250) {
//        yes = true;
//      }
//    }
//    Serial.println();
//    if (yes) {
//      Serial.println("yes");
//    } else {
//      Serial.println("no");
//    }
//    delay(100);
}

int read_lidar(int serial_port) {
    byte bytes[9];
    if (serial_port == 4) {
      LEFT_LIDAR_SERIAL.readBytes(bytes, 9);
    } else {
      RIGHT_LIDAR_SERIAL.readBytes(bytes, 9);
    }
//    Serial.println(String(bytes[0]) + " " + String(bytes[1]) + " " + String(bytes[2]) + " " + String(bytes[3]) + " " + String(bytes[4]) + " " + String(bytes[5]) + " " + String(bytes[6]) + " " + String(bytes[7]) + " " + String(bytes[8]));
    int dist_low = 0;
    int value = -1;
    while (dist_low < 9 && value == -1) {
        if (bytes[dist_low] == 0x59) {
            if (dist_low == 0) {
                if (bytes[8] == 0x59) {
                    value = bytes[1] + (bytes[2] << 8);
                } else if (bytes[1] == 0x59) {
                    value = bytes[2] + (bytes[3] << 8);
                }
            } else if (dist_low == 7) {
                if (bytes[8] == 0x59) {
                    value = bytes[0] + (bytes[1] << 8);
                }
            } else {
                if (bytes[++dist_low] == 0x59) {
                    value = bytes[++dist_low] + ((bytes[++dist_low]) << 8);
                }
            }
        }
        dist_low++;
//    Serial.println(value);
    }
    if (value == 0 || value == -1) {
        return MAX_DIST+1;
    }
    delay(1);
    return value;
}
