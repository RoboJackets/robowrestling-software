File: Gucci/v4 pcb/Gucci_ControlBoard.sch (EAGLE design)
At the start: 65 parts, among them U1 PCA9306_LSSOP, U2 TEENSY_3.6_DIL, U5 LM393-8-SOIC, U6 AP2114H-1.8TRG1, U7 AP2114H-3.3TRG1

Commit message: Added Pull-up Resistors/Moved MUXs
Added Pull-up Resistors (1k OHM to RX line)
Added 6.2 OHM to 1.8 V LED
Moved MUXs and rerouted
Fixed SIlkscreen
Parts:
- added R2: 6.2, Kirbi_ControlBoard:6.2OHM-0603-1/10W-5%
- added R3, R4, R5: 1k, SparkFun-Resistors:1KOHM-0603-1/10W-1%
- F1: value BEL_FUSE_C1F_3.5 -> 3.5
- renumbered U$2 to F1
Connections:
- new net N$9: D4.C, R2.1
- net +3.3V: now also R3.2, R4.2, R5.2
- net ESC_TRX: now also R5.1
- net GND: now also R2.2; no longer D4.C
- net TRX1: now also R4.1
- net TRX2: now also R3.1
Changed lines of the file:
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@@
 <part name="C25" library="SparkFun-Capacitors" library_urn="urn:adsk.eagle:library:510" deviceset="0.1UF" device="-0603-25V-(+80/-20%)" package3d_urn="urn:adsk.eagle:package:37414/1" value="0.1uF"/>
 <part name="POWER_CONN" library="Kirbi_ControlBoard" deviceset="MOLEX_2.54MM_2PIN" device=""/>
-<part name="U$2" library="Kirbi_ControlBoard" deviceset="BEL_FUSE_C1F_3.5" device=""/>
 <part name="C12" library="SparkFun-Capacitors" library_urn="urn:adsk.eagle:library:510" deviceset="0.1UF" device="-0603-25V-(+80/-20%)" package3d_urn="urn:adsk.eagle:package:37414/1" value="0.1uF"/>
 <part name="ESC_RX" library="Kirbi_ControlBoard" deviceset="MUX_74LVC1G157GV" device=""/>
@@
 <part name="GND21" library="SparkFun-PowerSymbols" library_urn="urn:adsk.eagle:library:530" deviceset="GND" device=""/>
 <part name="GND27" library="SparkFun-PowerSymbols" library_urn="urn:adsk.eagle:library:530" deviceset="GND" device=""/>
+<part name="F1" library="Kirbi_ControlBoard" deviceset="BEL_FUSE_C1F_3.5" device="" value="3.5"/>
+<part name="R2" library="Kirbi_ControlBoard" deviceset="6.2OHM" device="-0603-1/10W-5%" package3d_urn="urn:adsk.eagle:package:39650/1" value="6.2"/>
+<part name="R3" library="SparkFun-Resistors" library_urn="urn:adsk.eagle:library:532" deviceset="1KOHM" device="-0603-1/10W-1%" package3d_urn="urn:adsk.eagle:package:39650/1" value="1k"/>
+<part name="R4" library="SparkFun-Resistors" library_urn="urn:adsk.eagle:library:532" deviceset="1KOHM" device="-0603-1/10W-1%" package3d_urn="urn:adsk.eagle:package:39650/1" value="1k"/>
+<part name="R5" library="SparkFun-Resistors" library_urn="urn:adsk.eagle:library:532" deviceset="1KOHM" device="-0603-1/10W-1%" package3d_urn="urn:adsk.eagle:package:39650/1" value="1k"/>
+<part name="+3V18" library="supply1" library_urn="urn:adsk.eagle:library:371" deviceset="+3V3" device=""/>
+<part name="+3V19" library="supply1" library_urn="urn:adsk.eagle:library:371" deviceset="+3V3" device=""/>
 </parts>
 <sheets>
@@
 <attribute name="VALUE" x="262.636" y="93.98" size="1.778" layer="95"/>
 </instance>
-<instance part="U$2" gate="G$1" x="279.4" y="104.14" smashed="yes"/>
 <instance part="C12" gate="G$1" x="58.42" y="228.6" smashed="yes">
 <attribute name="NAME" x="59.944" y="231.521" size="1.778" layer="95" font="vector"/>
@@
 <instance part="GND27" gate="1" x="317.5" y="170.18" smashed="yes">
 <attribute name="VALUE" x="317.5" y="169.926" size="1.778" layer="96" align="top-center"/>
+</instance>
+<instance part="F1" gate="G$1" x="279.4" y="104.14" smashed="yes">
+<attribute name="NAME" x="276.86" y="106.68" size="1.778" layer="95"/>
+<attribute name="VALUE" x="276.86" y="100.33" size="1.778" layer="96"/>
+</instance>
+<instance part="R2" gate="G$1" x="292.1" y="33.02" smashed="yes">
+<attribute name="NAME" x="292.1" y="34.544" size="1.778" layer="95" font="vector" align="bottom-center"/>
+<attribute name="VALUE" x="292.1" y="31.496" size="1.778" layer="96" font="vector" align="top-center"/>
+</instance>
+<instance part="R3" gate="G$1" x="121.412" y="214.884" smashed="yes" rot="R90">
+<attribute name="NAME" x="119.888" y="214.884" size="1.778" layer="95" font="vector" rot="R90" align="bottom-center"/>
+<attribute name="VALUE" x="122.936" y="214.884" size="1.778" layer="96" font="vector" rot="R90" align="top-center"/>
+</instance>
+<instance part="R4" gate="G$1" x="128.524" y="215.138" smashed="yes" rot="R90">
+<attribute name="NAME" x="127" y="215.138" size="1.778" layer="95" font="vector" rot="R90" align="bottom-center"/>
+<attribute name="VALUE" x="130.048" y="215.138" size="1.778" layer="96" font="vector" rot="R90" align="top-center"/>
+</instance>
+<instance part="R5" gate="G$1" x="137.16" y="157.48" smashed="yes" rot="R90">
+<attribute name="NAME" x="135.636" y="157.48" size="1.778" layer="95" font="vector" rot="R90" align="bottom-center"/>
+<attribute name="VALUE" x="138.684" y="157.48" size="1.778" layer="96" font="vector" rot="R90" align="top-center"/>
+</instance>
+<instance part="+3V18" gate="G$1" x="121.412" y="224.282" smashed="yes">
+<attribute name="VALUE" x="119.38" y="219.456" size="1.778" layer="96" rot="R90"/>
+</instance>
+<instance part="+3V19" gate="G$1" x="137.16" y="166.624" smashed="yes">
+<attribute name="VALUE" x="134.62" y="161.544" size="1.778" layer="96" rot="R90"/>
 </instance>
 </instances>
@@
 <pinref part="ESC_RX" gate="G$1" pin="V"/>
 <wire x1="312.42" y1="167.894" x2="312.42" y2="165.1" width="0.1524" layer="91"/>
+</segment>
+<segment>
+<pinref part="+3V19" gate="G$1" pin="+3V3"/>
+<pinref part="R5" gate="G$1" pin="2"/>
+<wire x1="137.16" y1="164.084" x2="137.16" y2="162.56" width="0.1524" layer="91"/>
+</segment>
+<segment>
+<pinref part="+3V18" gate="G$1" pin="+3V3"/>
+<pinref part="R3" gate="G$1" pin="2"/>
+<wire x1="121.412" y1="221.742" x2="121.412" y2="219.964" width="0.1524" layer="91"/>
+<pinref part="R4" gate="G$1" pin="2"/>
+<wire x1="128.524" y1="220.218" x2="121.412" y2="219.964" width="0.1524" layer="91"/>
+<junction x="121.412" y="219.964"/>
 </segment>
 </net>
@@
 </segment>
 <segment>
-<pinref part="D4" gate="G$1" pin="C"/>
 <pinref part="GND28" gate="1" pin="GND"/>
 <wire x1="304.8" y1="30.48" x2="304.8" y2="33.02" width="0.1524" layer="91"/>
-<wire x1="304.8" y1="33.02" x2="279.4" y2="33.02" width="0.1524" layer="91"/>
+<pinref part="R2" gate="G$1" pin="2"/>
+<wire x1="304.8" y1="33.02" x2="297.18" y2="33.02" width="0.1524" layer="91"/>
 </segment>
 <segment>
@@
 <segment>
 <pinref part="U2" gate="G$1" pin="7/RX3/PWM"/>
-<wire x1="165.1" y1="218.44" x2="160.02" y2="218.44" width="0.1524" layer="91"/>
-<label x="160.02" y="218.44" size="1.778" layer="95" rot="MR0" xref="yes"/>
+<wire x1="165.1" y1="218.44" x2="144.78" y2="218.44" width="0.1524" layer="91"/>
+<label x="142.24" y="218.44" size="1.778" layer="95" rot="MR0" xref="yes"/>
+<pinref part="R4" gate="G$1" pin="1"/>
+<wire x1="144.78" y1="218.44" x2="142.24" y2="218.44" width="0.1524" layer="91"/>
+<wire x1="128.524" y1="210.058" x2="128.524" y2="208.28" width="0.1524" layer="91"/>
+<wire x1="128.524" y1="208.28" x2="132.08" y2="208.28" width="0.1524" layer="91"/>
+<wire x1="132.08" y1="208.28" x2="132.08" y2="220.98" width="0.1524" layer="91"/>
+<wire x1="132.08" y1="220.98" x2="144.78" y2="220.98" width="0.1524" layer="91"/>
+<wire x1="144.78" y1="220.98" x2="144.78" y2="218.44" width="0.1524" layer="91"/>
+<junction x="144.78" y="218.44"/>
 </segment>
 </net>
@@
 <segment>
 <pinref part="U2" gate="G$1" pin="9/RX2/PWM"/>
-<wire x1="165.1" y1="213.36" x2="160.02" y2="213.36" width="0.1524" layer="91"/>
-<label x="160.02" y="213.36" size="1.778" layer="95" rot="MR0" xref="yes"/>
+<wire x1="165.1" y1="213.36" x2="142.24" y2="213.36" width="0.1524" layer="91"/>
+<label x="142.24" y="213.36" size="1.778" layer="95" rot="MR0" xref="yes"/>
+<wire x1="142.24" y1="213.36" x2="142.24" y2="205.74" width="0.1524" layer="91"/>
+<wire x1="142.24" y1="205.74" x2="121.92" y2="205.74" width="0.1524" layer="91"/>
+<pinref part="R3" gate="G$1" pin="1"/>
+<wire x1="121.92" y1="205.74" x2="121.412" y2="209.804" width="0.1524" layer="91"/>
 </segment>
 </net>
@@
 <net name="N$7" class="0">
 <segment>
-<pinref part="U$2" gate="G$1" pin="P$1"/>
 <pinref part="POWER_CONN" gate="G$1" pin="P$1"/>
 <wire x1="274.32" y1="104.14" x2="276.86" y2="104.14" width="0.1524" layer="91"/>
+<pinref part="F1" gate="G$1" pin="P$1"/>
 </segment>
 </net>
 <net name="N$6" class="0">
 <segment>
-<pinref part="U$2" gate="G$1" pin="P$2"/>
 <wire x1="281.94" y1="104.14" x2="284.48" y2="104.14" width="0.1524" layer="91"/>
 <wire x1="284.48" y1="104.14" x2="284.48" y2="110.49" width="0.1524" layer="91"/>
 <pinref part="POWER" gate="G$1" pin="P4"/>
 <wire x1="284.48" y1="110.49" x2="286.512" y2="110.49" width="0.1524" layer="91"/>
+<pinref part="F1" gate="G$1" pin="P$2"/>
 </segment>
 </net>
@@
 <segment>
 <pinref part="U2" gate="G$1" pin="34/A15/RX5/CAN1-RX"/>
-<wire x1="165.1" y1="149.86" x2="160.02" y2="149.86" width="0.1524" layer="91"/>
-<label x="160.02" y="149.86" size="1.778" layer="95" rot="MR0" xref="yes"/>
-</segment>
-</net>
+<wire x1="165.1" y1="149.86" x2="137.16" y2="149.86" width="0.1524" layer="91"/>
+<label x="134.62" y="149.86" size="1.778" layer="95" rot="MR0" xref="yes"/>
+<pinref part="R5" gate="G$1" pin="1"/>
+<wire x1="137.16" y1="149.86" x2="134.62" y2="149.86" width="0.1524" layer="91"/>
+<wire x1="137.16" y1="152.4" x2="137.16" y2="149.86" width="0.1524" layer="91"/>
+<junction x="137.16" y="149.86"/>
+</segment>
+</net>
+<net name="N$9" class="0">
+<segment>
+<pinref part="R2" gate="G$1" pin="1"/>
+<pinref part="D4" gate="G$1" pin="C"/>
+<wire x1="287.02" y1="33.02" x2="279.4" y2="33.02" width="0.1524" layer="91"/>
+</segment>
+</net>

Commit message: esc routing fix
Connections:
- net GND: now also ESC_RX.GND, ESC_TX.GND
Changed lines of the file:
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@@
 <?xml version="1.0" encoding="utf-8"?>
 <!DOCTYPE eagle SYSTEM "eagle.dtd">
-<eagle version="9.5.1">
+<eagle version="9.5.2">
 <drawing>
 <settings>
@@
 <part name="+3V18" library="supply1" library_urn="urn:adsk.eagle:library:371" deviceset="+3V3" device=""/>
 <part name="+3V19" library="supply1" library_urn="urn:adsk.eagle:library:371" deviceset="+3V3" device=""/>
+<part name="GND29" library="SparkFun-PowerSymbols" library_urn="urn:adsk.eagle:library:530" deviceset="GND" device=""/>
+<part name="GND30" library="SparkFun-PowerSymbols" library_urn="urn:adsk.eagle:library:530" deviceset="GND" device=""/>
 </parts>
 <sheets>
@@
 <attribute name="VALUE" x="134.62" y="161.544" size="1.778" layer="96" rot="R90"/>
 </instance>
+<instance part="GND29" gate="1" x="274.32" y="132.08" smashed="yes">
+<attribute name="VALUE" x="274.32" y="131.826" size="1.778" layer="96" align="top-center"/>
+</instance>
+<instance part="GND30" gate="1" x="312.42" y="132.08" smashed="yes">
+<attribute name="VALUE" x="312.42" y="131.826" size="1.778" layer="96" align="top-center"/>
+</instance>
 </instances>
 <busses>
@@
 <pinref part="GND27" gate="1" pin="GND"/>
 </segment>
+<segment>
+<pinref part="ESC_RX" gate="G$1" pin="GND"/>
+<pinref part="GND30" gate="1" pin="GND"/>
+</segment>
+<segment>
+<pinref part="ESC_TX" gate="G$1" pin="GND"/>
+<pinref part="GND29" gate="1" pin="GND"/>
+</segment>
 </net>
