File: CurrentSensingBoard/sensor.sch (EAGLE design)
At the start: 13 parts, among them U1 MAX11634EEE+T21-0055H_16-L

Commit message: compacted board
Parts:
- renumbered RF1 to R1, U$2 to SENSOR_0, U$3 to SENSOR_1, U1 to 12-BIT_ADC
Connections:
- new net N$1: U$1.TX0
- new net TX_TEENSY: U$1.RX1
Changed lines of the file:
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@@
 <parts>
 <part name="U$1" library="I'mRADIOactive" deviceset="NANO" device=""/>
-<part name="U$2" library="CurrentSensing" deviceset="CQ2065" device=""/>
-<part name="U$3" library="CurrentSensing" deviceset="CQ2065" device=""/>
-<part name="U1" library="CurrentSensing" deviceset="MAX11634EEE+T" device="21-0055H_16-L"/>
-<part name="RF1" library="rcl" library_urn="urn:adsk.eagle:library:334" deviceset="R-US_" device="R0603" package3d_urn="urn:adsk.eagle:package:23555/3" value="RF0"/>
+<part name="SENSOR_0" library="CurrentSensing" deviceset="CQ2065" device=""/>
+<part name="SENSOR_1" library="CurrentSensing" deviceset="CQ2065" device=""/>
+<part name="12-BIT_ADC" library="CurrentSensing" deviceset="MAX11634EEE+T" device="21-0055H_16-L"/>
+<part name="R1" library="rcl" library_urn="urn:adsk.eagle:library:334" deviceset="R-US_" device="R0603" package3d_urn="urn:adsk.eagle:package:23555/3" value="RF0"/>
 <part name="R2" library="rcl" library_urn="urn:adsk.eagle:library:334" deviceset="R-US_" device="R0603" package3d_urn="urn:adsk.eagle:package:23555/3" value="RF1"/>
 <part name="C1" library="rcl" library_urn="urn:adsk.eagle:library:334" deviceset="C-US" device="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="CF0"/>
@@
 <instances>
 <instance part="U$1" gate="G$1" x="71.12" y="33.02" smashed="yes"/>
-<instance part="U$2" gate="G$1" x="-38.1" y="33.02" smashed="yes"/>
-<instance part="U$3" gate="G$1" x="-38.1" y="-40.64" smashed="yes"/>
-<instance part="U1" gate="A" x="71.12" y="-30.48" smashed="yes"/>
-<instance part="RF1" gate="G$1" x="-7.62" y="43.18" smashed="yes">
+<instance part="SENSOR_0" gate="G$1" x="-38.1" y="33.02" smashed="yes"/>
+<instance part="SENSOR_1" gate="G$1" x="-38.1" y="-40.64" smashed="yes"/>
+<instance part="12-BIT_ADC" gate="A" x="71.12" y="-30.48" smashed="yes"/>
+<instance part="R1" gate="G$1" x="-7.62" y="43.18" smashed="yes">
 <attribute name="NAME" x="-11.43" y="44.6786" size="1.778" layer="95"/>
 <attribute name="VALUE" x="-11.43" y="39.878" size="1.778" layer="96"/>
@@
 <attribute name="VALUE" x="35.56" y="-2.54" size="1.778" layer="96"/>
 </instance>
-<instance part="GND9" gate="1" x="83.82" y="15.24" smashed="yes">
-<attribute name="VALUE" x="81.28" y="12.7" size="1.778" layer="96"/>
+<instance part="GND9" gate="1" x="106.68" y="15.24" smashed="yes">
+<attribute name="VALUE" x="104.14" y="12.7" size="1.778" layer="96"/>
 </instance>
 <instance part="P+5" gate="1" x="38.1" y="20.32" smashed="yes">
@@
 <net name="GND" class="0">
 <segment>
-<pinref part="U$3" gate="G$1" pin="SCLK"/>
+<pinref part="SENSOR_1" gate="G$1" pin="SCLK"/>
 <wire x1="-15.24" y1="-22.86" x2="12.7" y2="-22.86" width="0.1524" layer="91"/>
 <wire x1="12.7" y1="-22.86" x2="12.7" y2="-38.1" width="0.1524" layer="91"/>
-<pinref part="U$3" gate="G$1" pin="DATA_IO"/>
+<pinref part="SENSOR_1" gate="G$1" pin="DATA_IO"/>
 <wire x1="12.7" y1="-38.1" x2="12.7" y2="-53.34" width="0.1524" layer="91"/>
 <wire x1="12.7" y1="-53.34" x2="-15.24" y2="-53.34" width="0.1524" layer="91"/>
-<pinref part="U$3" gate="G$1" pin="VSS"/>
+<pinref part="SENSOR_1" gate="G$1" pin="VSS"/>
 <wire x1="-15.24" y1="-38.1" x2="-12.7" y2="-38.1" width="0.1524" layer="91"/>
 <junction x="12.7" y="-38.1"/>
@@
 </segment>
 <segment>
-<pinref part="U$2" gate="G$1" pin="DATA_IO"/>
+<pinref part="SENSOR_0" gate="G$1" pin="DATA_IO"/>
 <wire x1="-15.24" y1="20.32" x2="12.7" y2="20.32" width="0.1524" layer="91"/>
-<pinref part="U$2" gate="G$1" pin="SCLK"/>
+<pinref part="SENSOR_0" gate="G$1" pin="SCLK"/>
 <wire x1="12.7" y1="20.32" x2="12.7" y2="35.56" width="0.1524" layer="91"/>
 <wire x1="12.7" y1="35.56" x2="12.7" y2="50.8" width="0.1524" layer="91"/>
 <wire x1="12.7" y1="50.8" x2="-15.24" y2="50.8" width="0.1524" layer="91"/>
-<pinref part="U$2" gate="G$1" pin="VSS"/>
+<pinref part="SENSOR_0" gate="G$1" pin="VSS"/>
 <wire x1="-15.24" y1="35.56" x2="-12.7" y2="35.56" width="0.1524" layer="91"/>
 <junction x="12.7" y="35.56"/>
@@
 </segment>
 <segment>
-<pinref part="U1" gate="A" pin="REF-"/>
+<pinref part="12-BIT_ADC" gate="A" pin="REF-"/>
 <wire x1="43.18" y1="-35.56" x2="27.94" y2="-35.56" width="0.1524" layer="91"/>
 <wire x1="27.94" y1="-35.56" x2="27.94" y2="-38.1" width="0.1524" layer="91"/>
@@
 </segment>
 <segment>
-<pinref part="U1" gate="A" pin="GND"/>
+<pinref part="12-BIT_ADC" gate="A" pin="GND"/>
 <wire x1="104.14" y1="-35.56" x2="116.84" y2="-35.56" width="0.1524" layer="91"/>
 <wire x1="116.84" y1="-35.56" x2="116.84" y2="-50.8" width="0.1524" layer="91"/>
@@
 <segment>
 <pinref part="U$1" gate="G$1" pin="GND2"/>
-<wire x1="81.28" y1="20.32" x2="83.82" y2="20.32" width="0.1524" layer="91"/>
-<wire x1="83.82" y1="20.32" x2="83.82" y2="17.78" width="0.1524" layer="91"/>
+<wire x1="81.28" y1="20.32" x2="106.68" y2="20.32" width="0.1524" layer="91"/>
+<wire x1="106.68" y1="20.32" x2="106.68" y2="17.78" width="0.1524" layer="91"/>
 <pinref part="GND9" gate="1" pin="GND"/>
 </segment>
@@
 <net name="N$3" class="0">
 <segment>
-<pinref part="U$3" gate="G$1" pin="VOUT"/>
+<pinref part="SENSOR_1" gate="G$1" pin="VOUT"/>
 <wire x1="-15.24" y1="-30.48" x2="-12.7" y2="-30.48" width="0.1524" layer="91"/>
 <pinref part="R2" gate="G$1" pin="1"/>
@@
 <net name="N$5" class="0">
 <segment>
-<pinref part="U$2" gate="G$1" pin="VOUT"/>
+<pinref part="SENSOR_0" gate="G$1" pin="VOUT"/>
 <wire x1="-15.24" y1="43.18" x2="-12.7" y2="43.18" width="0.1524" layer="91"/>
-<pinref part="RF1" gate="G$1" pin="1"/>
+<pinref part="R1" gate="G$1" pin="1"/>
 </segment>
 </net>
 <net name="+5V" class="0">
 <segment>
-<pinref part="U$2" gate="G$1" pin="VDD"/>
+<pinref part="SENSOR_0" gate="G$1" pin="VDD"/>
 <wire x1="-15.24" y1="27.94" x2="-12.7" y2="27.94" width="0.1524" layer="91"/>
 <wire x1="-12.7" y1="27.94" x2="0" y2="27.94" width="0.1524" layer="91"/>
@@
 </segment>
 <segment>
-<pinref part="U$3" gate="G$1" pin="VDD"/>
+<pinref part="SENSOR_1" gate="G$1" pin="VDD"/>
 <wire x1="-15.24" y1="-45.72" x2="-12.7" y2="-45.72" width="0.1524" layer="91"/>
 <wire x1="-12.7" y1="-45.72" x2="0" y2="-45.72" width="0.1524" layer="91"/>
@@
 </segment>
 <segment>
-<pinref part="U1" gate="A" pin="REF+"/>
+<pinref part="12-BIT_ADC" gate="A" pin="REF+"/>
 <wire x1="104.14" y1="-38.1" x2="109.22" y2="-38.1" width="0.1524" layer="91"/>
 <wire x1="109.22" y1="-38.1" x2="109.22" y2="-40.64" width="0.1524" layer="91"/>
@@
 </segment>
 <segment>
-<pinref part="U1" gate="A" pin="VDD"/>
+<pinref part="12-BIT_ADC" gate="A" pin="VDD"/>
 <wire x1="104.14" y1="-33.02" x2="124.46" y2="-33.02" width="0.1524" layer="91"/>
 <wire x1="124.46" y1="-33.02" x2="124.46" y2="-40.64" width="0.1524" layer="91"/>
@@
 <net name="AIN1" class="0">
 <segment>
-<pinref part="U1" gate="A" pin="AIN1"/>
+<pinref part="12-BIT_ADC" gate="A" pin="AIN1"/>
 <wire x1="43.18" y1="-22.86" x2="40.64" y2="-22.86" width="0.1524" layer="91"/>
 <label x="40.64" y="-22.86" size="1.778" layer="95" rot="R180" xref="yes"/>
@@
 <net name="!EOC!" class="0">
 <segment>
-<pinref part="U1" gate="A" pin="!EOC"/>
+<pinref part="12-BIT_ADC" gate="A" pin="!EOC"/>
 <wire x1="104.14" y1="-20.32" x2="106.68" y2="-20.32" width="0.1524" layer="91"/>
 <label x="106.68" y="-20.32" size="1.778" layer="95" xref="yes"/>
@@
 <net name="DOUT" class="0">
 <segment>
-<pinref part="U1" gate="A" pin="DOUT"/>
+<pinref part="12-BIT_ADC" gate="A" pin="DOUT"/>
 <wire x1="104.14" y1="-22.86" x2="106.68" y2="-22.86" width="0.1524" layer="91"/>
 <label x="106.68" y="-22.86" size="1.778" layer="95" xref="yes"/>
@@
 <net name="DIN" class="0">
 <segment>
-<pinref part="U1" gate="A" pin="DIN"/>
+<pinref part="12-BIT_ADC" gate="A" pin="DIN"/>
 <wire x1="104.14" y1="-25.4" x2="106.68" y2="-25.4" width="0.1524" layer="91"/>
 <label x="106.68" y="-25.4" size="1.778" layer="95" xref="yes"/>
@@
 <net name="SCLK" class="0">
 <segment>
-<pinref part="U1" gate="A" pin="SCLK"/>
+<pinref part="12-BIT_ADC" gate="A" pin="SCLK"/>
 <wire x1="104.14" y1="-27.94" x2="106.68" y2="-27.94" width="0.1524" layer="91"/>
 <label x="106.68" y="-27.94" size="1.778" layer="95" xref="yes"/>
@@
 <net name="!CS!" class="0">
 <segment>
-<pinref part="U1" gate="A" pin="!CS"/>
+<pinref part="12-BIT_ADC" gate="A" pin="!CS"/>
 <wire x1="104.14" y1="-30.48" x2="106.68" y2="-30.48" width="0.1524" layer="91"/>
 <label x="106.68" y="-30.48" size="1.778" layer="95" xref="yes"/>
@@
 <net name="AIN0" class="0">
 <segment>
-<pinref part="U1" gate="A" pin="AIN0"/>
+<pinref part="12-BIT_ADC" gate="A" pin="AIN0"/>
 <wire x1="43.18" y1="-20.32" x2="40.64" y2="-20.32" width="0.1524" layer="91"/>
 <label x="40.64" y="-20.32" size="1.778" layer="95" rot="R180" xref="yes"/>
 </segment>
 <segment>
-<pinref part="RF1" gate="G$1" pin="2"/>
+<pinref part="R1" gate="G$1" pin="2"/>
 <pinref part="C1" gate="G$1" pin="1"/>
 <wire x1="-2.54" y1="43.18" x2="0" y2="43.18" width="0.1524" layer="91"/>
@@
 <net name="!CNVST!" class="0">
 <segment>
-<pinref part="U1" gate="A" pin="!CNVST"/>
+<pinref part="12-BIT_ADC" gate="A" pin="!CNVST"/>
 <wire x1="43.18" y1="-38.1" x2="40.64" y2="-38.1" width="0.1524" layer="91"/>
 <label x="40.64" y="-38.1" size="1.778" layer="95" rot="R180" xref="yes"/>
@@
 </segment>
 </net>
+<net name="N$1" class="0">
+<segment>
+<pinref part="U$1" gate="G$1" pin="TX0"/>
+<wire x1="81.28" y1="12.7" x2="83.82" y2="12.7" width="0.1524" layer="91"/>
+<label x="83.82" y="12.7" size="1.778" layer="95" xref="yes"/>
+</segment>
+</net>
+<net name="TX_TEENSY" class="0">
+<segment>
+<pinref part="U$1" gate="G$1" pin="RX1"/>
+<wire x1="81.28" y1="15.24" x2="83.82" y2="15.24" width="0.1524" layer="91"/>
+<label x="83.82" y="15.24" size="1.778" layer="95" xref="yes"/>
+</segment>
+</net>

Commit message: implemented connector
Parts:
- added CONNECTOR: B2B-PH-K-S(LF)(SN), B2B-PH-K-S_LF__SN_:B2B-PH-K-S(LF)(SN)
Connections:
- removed net N$1: U$1.TX0
- new net RX_TEENSY: CONNECTOR.2, U$1.TX0
- net TX_TEENSY: now also CONNECTOR.1
Other:
- note added: "12-bit ADC"
- note added: "Arduino Nano Microcontroller"
- note added: "Hall Effect Current Sensors"
- note added: "TEENSY Connector"
- moved on the sheet: C1, C2, C3, C4, C5, C6, C7, R1, R2
