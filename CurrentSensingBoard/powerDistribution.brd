File: CurrentSensingBoard/powerDistribution.brd (EAGLE design)
At the start: 48 x 46 mm, 35 parts, among them J1 XT-60BATT_LABEL, U1 MAX11635EEE+, U2 LM2678SX-5.0/NOPB, U7 AP2114H-3.3TRG1

Commit message: added capictors
Parts:
- removed C10, C11, C13, C14, C7: 15uF, rcl:C0603
- added U$10, U$8, U$9: 15uF, CurrentSensing:15UF_CAP
- added U$6, U$7: 180uF, CurrentSensing:180UF_CAP
- C12: value 47uF -> 0.47uF
Connections:
- net FB: now also U$6.VIN, U$7.VIN; no longer C13.1, C14.1
- net GND: now also U$10.GND, U$6.GND, U$7.GND, U$8.GND, U$9.GND; no longer C10.2, C11.2, C13.2, C14.2, C7.2
- net VIN: now also U$10.VIN, U$8.VIN, U$9.VIN; no longer C10.1, C11.1, C7.1
Changed lines of the file:
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@@
 <attribute name="VENDOR" value="Texas Instruments" x="-67" y="-134" size="1.778" layer="27" display="off"/>
 </element>
-<element name="C7" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="15uF" x="-73" y="-148" smashed="yes">
-<attribute name="NAME" x="-73.635" y="-147.365" size="1.27" layer="25"/>
-<attribute name="POPULARITY" value="37" x="-73" y="-148" size="1.778" layer="27" display="off"/>
-<attribute name="SPICEPREFIX" value="C" x="-73" y="-148" size="1.778" layer="27" display="off"/>
-<attribute name="VALUE" x="-73.635" y="-149.905" size="1.27" layer="27"/>
-</element>
-<element name="C10" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="15uF" x="-73" y="-152" smashed="yes">
-<attribute name="NAME" x="-73.635" y="-151.365" size="1.27" layer="25"/>
-<attribute name="POPULARITY" value="37" x="-73" y="-152" size="1.778" layer="27" display="off"/>
-<attribute name="SPICEPREFIX" value="C" x="-73" y="-152" size="1.778" layer="27" display="off"/>
-<attribute name="VALUE" x="-73.635" y="-153.905" size="1.27" layer="27"/>
-</element>
-<element name="C11" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="15uF" x="-73" y="-156" smashed="yes">
-<attribute name="NAME" x="-73.635" y="-155.365" size="1.27" layer="25"/>
-<attribute name="POPULARITY" value="37" x="-73" y="-156" size="1.778" layer="27" display="off"/>
-<attribute name="SPICEPREFIX" value="C" x="-73" y="-156" size="1.778" layer="27" display="off"/>
-<attribute name="VALUE" x="-73.635" y="-157.905" size="1.27" layer="27"/>
-</element>
-<element name="C12" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="47uF" x="-73" y="-160" smashed="yes">
+<element name="C12" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="0.47uF" x="-73" y="-160" smashed="yes">
 <attribute name="NAME" x="-73.635" y="-159.365" size="1.27" layer="25"/>
 <attribute name="POPULARITY" value="37" x="-73" y="-160" size="1.778" layer="27" display="off"/>
 <attribute name="SPICEPREFIX" value="C" x="-73" y="-160" size="1.778" layer="27" display="off"/>
 <attribute name="VALUE" x="-73.635" y="-161.905" size="1.27" layer="27"/>
-</element>
-<element name="C13" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="15uF" x="-73" y="-165" smashed="yes">
-<attribute name="NAME" x="-73.635" y="-164.365" size="1.27" layer="25"/>
-<attribute name="POPULARITY" value="37" x="-73" y="-165" size="1.778" layer="27" display="off"/>
-<attribute name="SPICEPREFIX" value="C" x="-73" y="-165" size="1.778" layer="27" display="off"/>
-<attribute name="VALUE" x="-73.635" y="-166.905" size="1.27" layer="27"/>
-</element>
-<element name="C14" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="15uF" x="-73" y="-170" smashed="yes">
-<attribute name="NAME" x="-73.635" y="-169.365" size="1.27" layer="25"/>
-<attribute name="POPULARITY" value="37" x="-73" y="-170" size="1.778" layer="27" display="off"/>
-<attribute name="SPICEPREFIX" value="C" x="-73" y="-170" size="1.778" layer="27" display="off"/>
-<attribute name="VALUE" x="-73.635" y="-171.905" size="1.27" layer="27"/>
 </element>
 <element name="C15" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="100nF" x="-73" y="-175" smashed="yes">
@@
 <attribute name="VALUE" x="-73.635" y="-176.905" size="1.27" layer="27"/>
 </element>
+<element name="U$6" library="CurrentSensing" package="180UF_CAP" value="180uF" x="-71" y="-181" smashed="yes"/>
+<element name="U$7" library="CurrentSensing" package="180UF_CAP" value="180uF" x="-71" y="-188" smashed="yes"/>
+<element name="U$8" library="CurrentSensing" package="15UF_CAP" value="15uF" x="-68" y="-197" smashed="yes"/>
+<element name="U$9" library="CurrentSensing" package="15UF_CAP" value="15uF" x="-68" y="-205" smashed="yes"/>
+<element name="U$10" library="CurrentSensing" package="15UF_CAP" value="15uF" x="-68" y="-213" smashed="yes"/>
 </elements>
 <signals>
@@
 <contactref element="R12" pad="2"/>
 <contactref element="C4" pad="2"/>
-<contactref element="C7" pad="2"/>
 <contactref element="C12" pad="2"/>
-<contactref element="C10" pad="2"/>
-<contactref element="C11" pad="2"/>
 <contactref element="U2" pad="4"/>
 <contactref element="U$2" pad="1"/>
 <contactref element="U$2" pad="3"/>
-<contactref element="C14" pad="2"/>
-<contactref element="C13" pad="2"/>
-<wire x1="-72.15" y1="-165" x2="-72.15" y2="-170" width="0" layer="19" extent="1-1"/>
-<wire x1="-72.15" y1="-160" x2="-72.15" y2="-165" width="0" layer="19" extent="1-1"/>
-<wire x1="-72.15" y1="-156" x2="-72.15" y2="-160" width="0" layer="19" extent="1-1"/>
-<wire x1="-72.15" y1="-152" x2="-72.15" y2="-156" width="0" layer="19" extent="1-1"/>
-<wire x1="-72.15" y1="-148" x2="-72.15" y2="-152" width="0" layer="19" extent="1-1"/>
-<wire x1="-67" y1="-142.2804" x2="-72.15" y2="-148" width="0" layer="19" extent="1-1"/>
+<contactref element="U$6" pad="GND"/>
+<contactref element="U$7" pad="GND"/>
+<contactref element="U$8" pad="GND"/>
+<contactref element="U$9" pad="GND"/>
+<contactref element="U$10" pad="GND"/>
+<wire x1="-72.25" y1="-188" x2="-72.25" y2="-181" width="0" layer="19" extent="1-1"/>
+<wire x1="-64.85" y1="-197" x2="-72.25" y2="-188" width="0" layer="19" extent="1-1"/>
+<wire x1="-64.85" y1="-205" x2="-64.85" y2="-197" width="0" layer="19" extent="1-1"/>
+<wire x1="-64.85" y1="-213" x2="-64.85" y2="-205" width="0" layer="19" extent="1-1"/>
+<wire x1="-72.15" y1="-160" x2="-72.25" y2="-181" width="0" layer="19" extent="1-1"/>
+<wire x1="-67" y1="-142.2804" x2="-72.15" y2="-160" width="0" layer="19" extent="1-1"/>
 <wire x1="-47.9106" y1="-141.286" x2="-67" y2="-142.2804" width="0" layer="19" extent="1-1"/>
 <wire x1="-47.9106" y1="-136.714" x2="-47.9106" y2="-141.286" width="0" layer="19" extent="1-1"/>
@@
 <signal name="VIN">
 <contactref element="U2" pad="2"/>
-<contactref element="C7" pad="1"/>
-<contactref element="C10" pad="1"/>
-<contactref element="C11" pad="1"/>
 <contactref element="C12" pad="1"/>
-<wire x1="-73.85" y1="-156" x2="-73.85" y2="-160" width="0" layer="19" extent="1-1"/>
-<wire x1="-73.85" y1="-152" x2="-73.85" y2="-156" width="0" layer="19" extent="1-1"/>
-<wire x1="-73.85" y1="-148" x2="-73.85" y2="-152" width="0" layer="19" extent="1-1"/>
-<wire x1="-69.54" y1="-142.2804" x2="-73.85" y2="-148" width="0" layer="19" extent="1-1"/>
+<contactref element="U$8" pad="VIN"/>
+<contactref element="U$9" pad="VIN"/>
+<contactref element="U$10" pad="VIN"/>
+<wire x1="-69.54" y1="-142.2804" x2="-73.85" y2="-160" width="0" layer="19" extent="1-1"/>
+<wire x1="-71.15" y1="-197" x2="-73.85" y2="-160" width="0" layer="19" extent="1-1"/>
+<wire x1="-71.15" y1="-205" x2="-71.15" y2="-197" width="0" layer="19" extent="1-1"/>
+<wire x1="-71.15" y1="-213" x2="-71.15" y2="-205" width="0" layer="19" extent="1-1"/>
 </signal>
 <signal name="FB">
 <contactref element="U$1" pad="P$2"/>
-<contactref element="C14" pad="1"/>
-<contactref element="C13" pad="1"/>
 <contactref element="U2" pad="6"/>
-<wire x1="-73.85" y1="-165" x2="-73.85" y2="-170" width="0" layer="19" extent="1-1"/>
-<wire x1="-64.46" y1="-142.2804" x2="-73.85" y2="-165" width="0" layer="19" extent="1-1"/>
+<contactref element="U$6" pad="VIN"/>
+<contactref element="U$7" pad="VIN"/>
+<wire x1="-69.75" y1="-188" x2="-69.75" y2="-181" width="0" layer="19" extent="1-1"/>
+<wire x1="-64.46" y1="-142.2804" x2="-69.75" y2="-181" width="0" layer="19" extent="1-1"/>
 <wire x1="-53" y1="-127.95" x2="-64.46" y2="-142.2804" width="0" layer="19" extent="1-1"/>
 </signal>

Commit message: fixed Caleb's mess
changed caps and diode symbols
24v regulator footprint was weird
24v regulator schematic looking clean now
deleted unnecessary stuff in library
Parts:
- removed U$10, U$8, U$9: 15uF, CurrentSensing:15UF_CAP
- removed U$6, U$7: 180uF, CurrentSensing:180UF_CAP
- added C10, C7: 180uF, CurrentSensing:860010373009
- added C11, C13, C14: 15uF, CurrentSensing:TR3E156M050C0300
- moved U$2 84.3 mm to (-67.0, -222.0)
Connections:
- net CB renamed N$7
- net SW renamed N$6
- removed net FB: U$1.P$2, U$6.VIN, U$7.VIN, U2.6
- removed net VIN: C12.1, U$10.VIN, U$8.VIN, U$9.VIN, U2.2
- net +24V: now also C11.1, C12.1, C13.1, C14.1, U2.2
- net +5V: now also C10.1, C7.1, U$1.P$2, U2.6; no longer U2.7
- net GND: now also C10.2, C11.2, C13.2, C14.2, C7.2, U2.8; no longer U$10.GND, U$6.GND, U$7.GND, U$8.GND, U$9.GND

Commit message: added fuseholders
Parts:
- added F1, F2: (no value), RoboJackets-Fuses:FUSEHOLDER_3549_X2
Connections:
- new net MOTOR1: F1.1, F1.LEG1
- new net MOTOR2: F2.1, F2.LEG1
- new net N1: U$4.7
- new net N2: U$5.7
- new net P1: F1.2, F1.LEG2, U$4.6
- new net P2: F2.2, F2.LEG2, U$5.6
Changed lines of the file:
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@@
 <attribute name="VALUE" x="-85" y="-256" size="1.016" layer="27" align="top-left"/>
+</element>
+<element name="F1" library="RoboJackets-Fuses" package="FUSEHOLDER_3549_X2" value="" x="-97" y="-241" smashed="yes">
+<attribute name="NAME" x="-90.5" y="-243.5" size="1" layer="25" rot="R270"/>
+</element>
+<element name="F2" library="RoboJackets-Fuses" package="FUSEHOLDER_3549_X2" value="" x="-112" y="-241" smashed="yes">
+<attribute name="NAME" x="-105.5" y="-243.5" size="1" layer="25" rot="R270"/>
 </element>
 </elements>
@@
 <wire x1="-68.27" y1="-142.32" x2="-73.85" y2="-175" width="0" layer="19" extent="1-1"/>
 </signal>
+<signal name="MOTOR1">
+<contactref element="F1" pad="LEG1" route="any" routetag="G$1.1"/>
+<contactref element="F1" pad="1" route="any" routetag="G$1.1"/>
+</signal>
+<signal name="MOTOR2">
+<contactref element="F2" pad="LEG1" route="any" routetag="G$1.1"/>
+<contactref element="F2" pad="1" route="any" routetag="G$1.1"/>
+</signal>
+<signal name="N1">
+<contactref element="U$4" pad="7"/>
+</signal>
+<signal name="P1">
+<contactref element="U$4" pad="6"/>
+<contactref element="F1" pad="LEG2"/>
+<contactref element="F1" pad="2"/>
+<wire x1="-92.935" y1="-235.92" x2="-92.935" y2="-246.08" width="0" layer="19" extent="1-1"/>
+<wire x1="-14.575" y1="-21" x2="-92.935" y2="-235.92" width="0" layer="19" extent="1-1"/>
+</signal>
+<signal name="P2">
+<contactref element="U$5" pad="6"/>
+<contactref element="F2" pad="LEG2"/>
+<contactref element="F2" pad="2"/>
+<wire x1="-107.935" y1="-235.92" x2="-107.935" y2="-246.08" width="0" layer="19" extent="1-1"/>
+<wire x1="-14.575" y1="-83" x2="-107.935" y2="-235.92" width="0" layer="19" extent="1-1"/>
+</signal>
+<signal name="N2">
+<contactref element="U$5" pad="7"/>
+</signal>
 </signals>
