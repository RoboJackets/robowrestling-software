File: CurrentSensingBoard/powerDistribution.brd (EAGLE design)
At the start: 48 x 46 mm, 21 parts

Commit message: repurpose current sensing board
current sengins board becomes power distribution board
using stm32 instead of nano
Parts:
- added U$4: STM32F0, STM32F031C4T6:QFP50P900X900X160-48N
- moved U$3 0.60 mm to (3.13, 20.8)
Changed lines of the file:
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@@
 </element>
 <element name="SENSOR_0" library="CurrentSensing" package="CQ2065" value="CQ2065" x="36" y="38" smashed="yes">
-<attribute name="NAME" x="35.11" y="32.19" size="1.778" layer="25" rot="R90"/>
-<attribute name="VALUE" x="38.05" y="33.19" size="1.778" layer="27" rot="R90"/>
+<attribute name="NAME" x="35.11" y="32.19" size="1" layer="25" font="vector" rot="R90"/>
+<attribute name="VALUE" x="38.05" y="33.19" size="1" layer="27" font="vector" rot="R90"/>
 </element>
 <element name="SENSOR_1" library="CurrentSensing" package="CQ2065" value="CQ2065" x="12" y="38" smashed="yes">
-<attribute name="NAME" x="11.11" y="32.19" size="1.778" layer="25" rot="R90"/>
-<attribute name="VALUE" x="14.05" y="33.19" size="1.778" layer="27" rot="R90"/>
+<attribute name="NAME" x="11.11" y="32.19" size="1" layer="25" font="vector" rot="R90"/>
+<attribute name="VALUE" x="14.05" y="33.19" size="1" layer="27" font="vector" rot="R90"/>
 </element>
 <element name="12-BIT_ADC" library="CurrentSensing" package="21-0055H_16-L" value="MAX11634EEE+T21-0055H_16-L" x="20" y="11" smashed="yes">
@@
 <attribute name="POPULARITY" value="77" x="28" y="24" size="1.778" layer="27" rot="R180" display="off"/>
 <attribute name="SPICEPREFIX" value="R" x="28" y="24" size="1.778" layer="27" rot="R180" display="off"/>
-<attribute name="VALUE" x="22.765" y="22.195" size="1" layer="27"/>
+<attribute name="VALUE" x="24.025" y="23.035" size="1" layer="27" font="vector"/>
 </element>
 <element name="R2" library="rcl" library_urn="urn:adsk.eagle:library:334" package="R0603" package3d_urn="urn:adsk.eagle:package:23555/3" value="RF1" x="19" y="24" smashed="yes">
 <attribute name="POPULARITY" value="77" x="19" y="24" size="1.778" layer="27" display="off"/>
 <attribute name="SPICEPREFIX" value="R" x="19" y="24" size="1.778" layer="27" display="off"/>
-<attribute name="VALUE" x="20.565" y="23.895" size="1" layer="27"/>
+<attribute name="VALUE" x="21.005" y="23.055" size="1" layer="27" font="vector"/>
 </element>
 <element name="C1" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="CF0" x="28" y="27" smashed="yes" rot="R180">
 <attribute name="POPULARITY" value="37" x="28" y="27" size="1.778" layer="27" rot="R180" display="off"/>
 <attribute name="SPICEPREFIX" value="C" x="28" y="27" size="1.778" layer="27" rot="R180" display="off"/>
-<attribute name="VALUE" x="26.335" y="26.505" size="1" layer="27" rot="R180"/>
+<attribute name="VALUE" x="26.125" y="26.425" size="1" layer="27" font="vector" rot="R180"/>
 </element>
 <element name="C2" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="CF1" x="19" y="27" smashed="yes">
 <attribute name="POPULARITY" value="37" x="19" y="27" size="1.778" layer="27" display="off"/>
 <attribute name="SPICEPREFIX" value="C" x="19" y="27" size="1.778" layer="27" display="off"/>
-<attribute name="VALUE" x="20.885" y="27.665" size="1" layer="27"/>
+<attribute name="VALUE" x="20.815" y="25.395" size="1" layer="27" font="vector"/>
 </element>
 <element name="C3" library="rcl" library_urn="urn:adsk.eagle:library:334" package="C0603" package3d_urn="urn:adsk.eagle:package:23616/2" value="0.1uF" x="19" y="21" smashed="yes" rot="R180">
@@
 </element>
 <element name="R3" library="rcl" library_urn="urn:adsk.eagle:library:334" package="R0603" package3d_urn="urn:adsk.eagle:package:23555/3" value="10k" x="34.3" y="14.1" smashed="yes" rot="R90">
-<attribute name="NAME" x="37.605" y="16.645" size="1" layer="25" font="vector" rot="R180"/>
+<attribute name="NAME" x="37.395" y="16.555" size="1" layer="25" font="vector" rot="R180"/>
 <attribute name="POPULARITY" value="77" x="34.3" y="14.1" size="1.778" layer="27" rot="R90" display="off"/>
 <attribute name="SPICEPREFIX" value="R" x="34.3" y="14.1" size="1.778" layer="27" rot="R90" display="off"/>
@@
 <attribute name="SPICEPREFIX" value="R" x="37.9" y="8" size="1.778" layer="27" rot="R90" display="off"/>
 </element>
-<element name="U$3" library="RoboJackets-Aesthetics" package="ROBOBUZZ_0.4X" value="" x="3.68" y="21.02" smashed="yes"/>
+<element name="U$3" library="RoboJackets-Aesthetics" package="ROBOBUZZ_0.4X" value="" x="3.13" y="20.77" smashed="yes"/>
+<element name="U$4" library="STM32F031C4T6" package="QFP50P900X900X160-48N" value="STM32F0" x="-6" y="8" smashed="yes">
+<attribute name="NAME" x="-11" y="14" size="1.27" layer="25"/>
+<attribute name="VALUE" x="-11" y="2" size="1.27" layer="27" align="top-left"/>
+</element>
 </elements>
 <signals>

Commit message: switched back to Nano
Parts:
- removed 12-BIT_ADC: MAX11634EEE+T21-0055H_16-L, CurrentSensing:21-0055H_16-L
- removed SENSOR_0, SENSOR_1: CQ2065, CurrentSensing:CQ2065
- added C8, C9: 4.7uF, rcl:C0603
- added R10, R14: RF1, rcl:R0603
- added R11, R12, R7, R8: 39k, rcl:R0603
- added R13, R9: 20k, rcl:R0603
- added U$5: CQ2065, CurrentSensing:CQ2065
- added U1: MAX11635EEE+, CurrentSensing:21-0055H_16_MXM
- added U7: AP2114H-3.3TRG1, Gucci_ControlBoard:SOT-223
- C1: value CF0 -> 0.1uF
- C2: value CF1 -> 0.1uF
- C3, C4: value 0.1uF -> CF1
- R1: value RF0 -> 20k
- R2: value RF1 -> 20k
- U$4: value STM32F0 -> CQ2065; device STM32F031C4T6:QFP50P900X900X160-48N -> CurrentSensing:CQ2065
- moved C4 140.0 mm to (-31.0, -106.0)
- moved R1 134.4 mm to (-6.00, -106.0), turned to 0 degrees
- moved C1 106.9 mm to (-7.00, -74.0), turned to 0 degrees
- moved C3 103.0 mm to (-31.0, -69.0), turned to 0 degrees
- moved R2 88.5 mm to (-31.0, -49.0)
- moved C2 86.8 mm to (-31.0, -44.0)
- moved C6 35.8 mm to (-7.00, -7.00), turned to 0 degrees
- moved U$4 32.6 mm to (-21.0, -21.0)
- moved C5 30.7 mm to (-7.00, -3.00)
Connections:
- removed net N$5: R1.1, SENSOR_0.4
- new net N$1: R1.1, U$5.4
- new net N$2: R10.2, R2.2, R7.2
- new net N$4: R1.2, R11.2, R14.2
- new net VDD: C6.1, U1.11
- new net VREF: R12.1, R13.1, R8.1, R9.1, U1.9
- new net VSS: C1.1, C2.1, C3.2, C4.2, R11.1, R12.2, R7.1, R8.2, U$4.1, U$4.3, U$4.5, U$5.1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
- net !CNVST!: now also U1.8; no longer 12-BIT_ADC.8
- net !CS!: now also U1.12; no longer 12-BIT_ADC.12
- net !EOC!: now also U1.16; no longer 12-BIT_ADC.16
- net +3V3: now also C9.1, U7.2, U7.4
- net +5V: now also C1.2, C2.2, C8.1, R13.2, R9.2, U$4.2, U$5.2, U7.3; no longer 12-BIT_ADC.11, 12-BIT_ADC.9, C3.2, C4.2, C6.1, SENSOR_0.2, SENSOR_1.2
- net AIN0: now also C3.1, R10.1, U1.1; no longer 12-BIT_ADC.1, C1.1, R1.2
- net AIN1: now also C4.1, R14.1, U1.2; no longer 12-BIT_ADC.2, C2.1, R2.2
- net DIN: now also U1.14; no longer 12-BIT_ADC.14
- net DOUT: now also U1.15; no longer 12-BIT_ADC.15
- net GND: now also C8.2, C9.2, U1.7, U7.1; no longer 12-BIT_ADC.10, 12-BIT_ADC.7, C1.2, C2.2, C3.1, C4.1, SENSOR_0.1, SENSOR_0.3, SENSOR_0.5, SENSOR_1.1, SENSOR_1.3, SENSOR_1.5
- net N$3: now also U$4.4; no longer SENSOR_1.4
- net SCLK: now also U1.13; no longer 12-BIT_ADC.13
Routing:
- net AIN0: track 21.4 -> 0.00 mm
- net AIN1: track 18.4 -> 0.00 mm
- net GND: track 18.2 -> 1.15 mm, vias 7 -> 1
- net N$5: track 9.40 -> 0.00 mm
- net N$3: track 4.96 -> 0.00 mm
- net !CS!: track 14.2 -> 12.4 mm
- net DIN: track 9.54 -> 8.84 mm
- net SCLK: track 11.4 -> 10.8 mm
- net DOUT: track 7.86 -> 7.26 mm
- net !EOC!: track 5.60 -> 5.00 mm

Commit message: added data line connector
Parts:
- removed C7: 0.1uF, rcl:C0603
- removed Q1, Q2: (no value), Adafruit FET 4-Channel Shifter:ADAFRUIT_SOT23
- removed R3, R4, R5, R6: 10k, rcl:R0603
- removed U$1: NANO, I'mRADIOactive:NANO
- removed U$2: MOLEX_1.25MM_4PIN_90, Kirbi_ControlBoard:MOLEX_1.25MM_4PIN_90
- added JP1: (no value), pinhead:1X08/90
Connections:
- removed net DIN: U$1.D4, U1.14
- removed net DOUT: U$1.D5, U1.15
- removed net RX_NANO: Q1.3, R6.2, U$1.RX1
- removed net RX_TEENSY: Q2.2, R3.2, U$2.P$3
- removed net TX_NANO: Q2.3, R4.2, U$1.TX0
- removed net TX_TEENSY: Q1.2, R5.2, U$2.P$2
- new net MISO: JP1.5, U1.15
- new net MOSI: JP1.4, U1.14
- net !CNVST!: now also JP1.2; no longer U$1.D7
- net !CS!: now also JP1.7; no longer U$1.D2
- net !EOC!: now also JP1.6; no longer U$1.D6
- net +3V3: now also C5.1, C6.1; no longer Q1.1, Q2.1, R3.1, R5.1, U$1.3.3V
- net +5V: now also JP1.1; no longer C5.1, C7.1, R4.1, R6.1, U$1.GND, U$2.P$4
- net GND: now also JP1.8; no longer C7.2, U$1.GND1, U$1.RAW, U$2.P$1
- net SCLK: now also JP1.3; no longer U$1.D3
- net VDD: no longer C6.1
Routing:
- net +3V3: track 49.3 -> 0.00 mm
- net TX_NANO: track 43.4 -> 0.00 mm
- net TX_TEENSY: track 25.1 -> 0.00 mm
- net RX_TEENSY: track 17.6 -> 0.00 mm
- net RX_NANO: track 16.8 -> 0.00 mm
- net !CS!: track 12.4 -> 0.00 mm
- net !CNVST!: track 11.2 -> 0.00 mm
- net SCLK: track 10.8 -> 0.00 mm
- net DIN: track 8.84 -> 0.00 mm
- net DOUT: track 7.26 -> 0.00 mm
- net !EOC!: track 5.00 -> 0.00 mm
- net GND: track 1.15 -> 0.00 mm, vias 1 -> 0

Commit message: put in 24v-5v
Parts:
- added C10, C11, C13, C14, C7: 15uF, rcl:C0603
- added C12: 47uF, rcl:C0603
- added C15: 100nF, rcl:C0603
- added J1: XT-60BATT_LABEL, RoboJackets-Connectors:XT-60
- added U$1: 22uH, CurrentSensing:INDUCTOR22
- added U$2: MBRD835LT4G, CurrentSensing:SCHDIODE
- added U2: LM2678SX-5.0/NOPB, CurrentSensing:TS7B
Connections:
- new net +24V: J1.BATT
- new net CB: C15.1, U2.3
- new net FB: C13.1, C14.1, U$1.P$2, U2.6
- new net N$5: C5.1
- new net SW: C15.2, U$1.P$1, U$2.4, U2.1
- new net VIN: C10.1, C11.1, C12.1, C7.1, U2.2
- net +3V3: no longer C5.1
- net +5V: now also U2.7
- net GND: now also C1.1, C10.2, C11.2, C12.2, C13.2, C14.2, C4.2, C7.2, J1.GND, R11.1, R12.2, U$2.1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
- net VSS: no longer C1.1, C4.2, R11.1, R12.2, U$5.1, U$5.3, U$5.5
