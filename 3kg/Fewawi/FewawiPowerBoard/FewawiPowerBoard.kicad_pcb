# Repository RoboJackets/robowrestling-software

File README.md:

# robowrestling-software

## Setup Guide

### PlatformIO Setup

PlatformIO is the platform that we use to program our bot, using the Arduino library.
It is most well-integrated with VS Code. Therefore, VS Code is the recommended editor for our bot code.
If you don't have VS Code, you can get it from [here](https://code.visualstudio.com/) or through your OS's package manager
(winget for Windows, brew or MacPorts for macOS, or whatever your Linux distro uses).

There is some other support for other editors, but you'll be mostly on your own.
In theory, you could use something like Vim and use the PlatformIO command-line tools, but your code completion and error detection may not work.

The VS Code installation instructions are as follows:

1. Go to the [PlatformIO website](https://platformio.org/platformio-ide)

2. Click the "Get for VS Code" button and follow the install instructions
    - If you wish to use another IDE, you can try looking for instructions [on this page](https://platformio.org/install/integration). However, VS Code will work best (at least from my experience).

3. When you open a folder to work on code, make sure that the folder you open has a `platformio.ini` file directly in it. It has to be directly in the folder.
    - If you're going to make a new project, then
        - Click the PlatformIO icon on the side bar of VS Code and click "Create New Project"
        - In the new tab, click "New Project" on the right
        - Select your board (likely a Teensy 4.1) and the Arudino framework
        - Give it a name and optionally choose a location by unchecking "Use Default Location"
    - Alternatively, you can use `pio init` in a new folder if you have the CLI installed

### Git/Github Setup

This is the repository for our code. The other robowrestling repository isn't used for software.
If you haven't used Git before, GitHub has a tutorial [here](https://docs.github.com/en/get-started/getting-started-with-git).
The general workflow is
1. `git pull` (to get the most recent code from GitHub)
2. Write code
3. `git add .` (to add code to the repo)
4. `git commit -m "Short and descriptive message"`
5. `git push` (to send your code to GitHub)

Please be sure to work in your own branch (`git branch <name>` and then `git checkout <branch name>`) unless otherwise working with someone else.
  
1. Linking Accounts
    1. Sign in to your Robojackets Account: [my.robojackets.org](my.robotjackets.org)
    2. Click your name in the top right, click "Profile," scroll down to "Linked Accounts" and link your GitHub and Google account
    
2. Update Identity: [Guide](https://docs.github.com/en/get-started/quickstart/set-up-git)
    1. If you do not have Git installed on your computer, install it from [here](https://git-scm.com/downloads) or with your OS's package manager.

3. Generate a Personal Access Token (PAT) if needed (Make sure to not lose): 
    [Guide](https://docs.github.com/en/authentication/keeping-your-account-and-data-secure/creating-a-personal-access-token)
    1. If you know how to use SSH keys, you may also use those.

4. Download the Github Desktop App (Optional): [Download](https://desktop.github.com/)

5. Clone the robowrestling-software repository using `git clone <url>`: [repo](https://github.com/RoboJackets/robowrestling-software)

## C++ Intro

If you haven't used C++ or Arduino before, don't worry.
There are lots of tutorials on the internet and you can ask the Software STL or other teammates for help.

Here are some basic things to get you started with both C++ and Arduino.

```cpp
// file: main.cpp

#include <Arduino.h>  // adds the Arduino library
// May have other #include statements here to add other things
// For example, if you have classes for things

// Example pins
// #define <name> <value> basically makes an alias
#define LEFT_MOTOR_OUT_PIN 1
#define RIGHT_MOTOR_OUT_PIN 2
#define LIDAR_IN_PIN 3

// Setup function that runs once when the robot first starts up
// Put stuff here for setup, e.g. starting Serial connections and
// setting up pins
void setup() {
    pinMode(LIDAR_IN_PIN, INPUT);  // see how the #define'd LIDAR_IN_PIN is used here?
    pinMode(LEFT_MOTOR_OUT_PIN, OUTPUT);
    pinMode(RIGHT_MOTOR_OUT_PIN, OUTPUT);
}

// This function runs *after* the setup function does and will constantly loop
// while the bot runs
void loop() {
    // This is example code and may not work in an actual bot
    // Highly depends on your hardware
    
    // This code will do the following:
    // If the LIDAR_IN_PIN reads a 1 (sees something), then run the motors at 100%
    // Otherwise, turn in place and check again later if the lidar sees something
    if (digitalRead(LIDAR_IN_PIN) == 1) {
        analogWrite(LEFT_MOTOR_OUT_PIN, 100);
        analogWrite(RIGHT_MOTOR_OUT_PIN, 100);
    } else {
        analogWrite(LEFT_MOTOR_OUT_PIN, -100);
        analogWrite(RIGHT_MOTOR_OUT_PIN, 100);
    }
}
```

## Useful Resources

1. Competition Rules: [All Japan Sumo](https://www.fsi.co.jp/sumo/robot/en/rule.html)
2. Arduino Code Library Documentation: [Reference Page](https://www.arduino.cc/reference/en/)
3. Serial Communication: [Teensy Website](https://www.pjrc.com/teensy/td_uart.html)
4. Teensy 4.1 Documentation (newer bots): [Teensy 4.1](https://www.pjrc.com/store/teensy41.html)
4. Teensy 3.6 Documentation (Kirbi): [Teensy 3.6](https://www.pjrc.com/store/teensy36.html)
5. Teensy Pinout: [Google Drive](https://drive.google.com/drive/folders/1ci8a4ckSqtLVcKN8qR22PUycx4mC5XRj)

## KiCad design 3kg/Fewawi/FewawiPowerBoard/FewawiPowerBoard.kicad_pcb

Parts:
C1, C3: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C5: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C7: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
F1: FuseNotMotors; FUSC3215X83N
J1: Battery; AMASS_XT60-F_1x02_P7.20mm_Vertical
J2: MD_Power; PhoenixContact_MSTBA_2,5_2-G_1x02_P5.00mm_Horizontal
J3, J4: Conn_01x02; AMASS_XT30U-F_1x02_P5.0mm_Vertical
PS1: TSR_1-2450; CONV_TSR_1-2450; PARTREV Apr 27, 2020
Q1: SQM40P10-40L_GE3; SQM40P1040L_GE3; Mouser Part Number 78-SQM40P10-40L_GE3
Q2: SQ2318AES-T1_BE3; SOT95P237X112-3N; Mouser Part Number 78-SQ2318AES-T1_BE3
R1: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R4: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_SPST; SW_GF-123-0054
U1: L7812CV; CONV_TSR_1-2450; PARTREV 34

Connections:
34V: C5.1, C6.1, C7.1, F1.2, J2.1, Q1.2 (D)
GND: C1.1, C3.1, C5.2, C6.2, J1.1, J2.2, Q2.2 (S), R3.2
unnamed: J1.2, Q1.3 (S), R2.2, SW1.2 (B)
unnamed: J3.1, PS1.2 (GND)
unnamed: J3.2, PS1.3 (+VOUT)
unnamed: J4.1, U1.2 (GND)
unnamed: J4.2, U1.3 (OUT)
unnamed: C1.2, C3.2, F1.1, PS1.1 (+VIN), U1.1 (IN)
unnamed: C7.2, Q1.1 (G), R1.1, R2.1
unnamed: Q2.3 (D), R1.2
unnamed: Q2.1 (G), R3.1, R4.1
unnamed: R4.2, SW1.1 (A)

Notes on the sheet:
Power and Battery
Motor Driver
Voltage Regulators

Board: 2 copper layers, 49.0 x 56.0 mm, 19 parts (0 on the bottom side), 12 nets.

## KiCad design 500g/Teddi/500g Bot Design - Teddi/500g Bot Design.kicad_pcb

Board: 2 copper layers, 78.2 x 52.7 mm, 26 parts (0 on the bottom side), 17 nets.

Parts:
C1, C8, C9: .1 uF; C_0201_0603Metric
C2, C3, C4, C5, C6, C7, C10, C11: 0.1uF; C_0201_0603Metric
IC1: TEENSY_4.1; TEENSY41
J1: Long IR Sensor 1; JST_B4B-XH-A_LF__SN_
J2: Long IR Sensor 2; JST_B4B-XH-A_LF__SN_
J3: Short IR Sensor 2; JST_B4B-XH-A_LF__SN_
J4: Short IR Sensor 1; JST_B4B-XH-A_LF__SN_
J5: Line Sensor 1; JST_B4B-XH-A_LF__SN_
J6: Line Sensor 2; JST_B4B-XH-A_LF__SN_
J7: Line Sensor 3; JST_B4B-XH-A_LF__SN_
J10: Battery Socket; PinSocket_1x02_P1.00mm_Vertical_SMD_Pin1Left
J11: IR Start Module; TE_5-146280-3
L2: 4.7 uH; INDC2012X145N
R1: 5kΩ; RESC1608X50N
R2: 50kΩ; robo
U1: TB67H303HG (MD); TO100P2930X465X1937-25
U2: TPS562200 (VR); SOT-23-6

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C10.1, C11.1, IC1.55 (VIN_(3.6_TO_5.5_VOLTS)), J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J11.1, L2.2, R1.2
+12V: C8.1, U1.6 (VCC), U1.20 (VCC), U2.3 (VIN), U2.5 (EN)
B_LINE: IC1.18 (A4), J7.2
GND: C8.2, U1.17 (PGNDA)
GNDS: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.1, C9.1, C10.2, C11.2, J1.4, J2.4, J3.4, J4.4, J5.4, J6.4, J7.4, J11.2, L2.1, R2.2, U1.2 (SGND), U2.1 (GND), U2.2 (SW)
IR_START: IC1.27 (A13), J11.3
LF_LINE: IC1.19 (A5), J5.2
LF_LIR: IC1.21 (A7), J2.2
LS_SIR: IC1.23 (A9), J3.2
M_REF: IC1.26 (A12), U1.5 (VREF)
M_SPD: IC1.25 (A11), U1.22 (PWM)
unnamed: C7.2, U1.24 (VREG)
unnamed: C9.2, U2.6 (VBST)
unnamed: R1.1, R2.1, U2.4 (VFB)
RF_LINE: IC1.20 (A6), J6.2
RF_LIR: IC1.22 (A8), J1.2
RS_SIR: IC1.24 (A10), J4.2

## KiCad design ShawtiBoard/RatatoulliBoard/RatatoulliBoard.kicad_pcb

Parts:
C1, C2, C4, C5, C8, C9, C10, C13, C14, C15, C16, C17, C18: 0.1uF; C_0805_2012Metric
C3, C6: 10uF; C_0805_2012Metric
C7, C11, C12: 47uF; C_1210_3225Metric
D1, D2: SSB43L-E3_52T; DIOM5436X244N; Manufacturer_Part_Number SSB43L-E3/52T; Mouser Part Number 625-SSB43L-E3
D3, D4, D5: GREEN; C_0603_1608Metric
F1, F2: 3A; C_1206_3216Metric
IC1: TEENSY_4.1; TEENSY41; Manufacturer_Part_Number TEENSY 4.1
IC2, IC3: DRV8212DRLR; SOTFL50P160X60-6N; Manufacturer_Part_Number DRV8212DRLR; Mouser Part Number 595-DRV8212DRLR
J1: BDC1; PhoenixContact_MSTBA_2,5_2-G_1x02_P5.00mm_Horizontal
J2: BDC2; PhoenixContact_MSTBA_2,5_2-G_1x02_P5.00mm_Horizontal
J3: LIDAR1; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J4: LIDAR2; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J5: LIDAR3; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J6: LIDAR4; JST_SH_SM04B-SRSS-TB_1x04-1MP_P1.00mm_Horizontal
J7: LINE_RF; PhoenixContact_MSTBA_2,5_3-G_1x03_P5.00mm_Horizontal
J8: LINE_LF; PhoenixContact_MSTBA_2,5_3-G_1x03_P5.00mm_Horizontal
J9: Battery; Molex_PicoBlade_53261-0271_1x02-1MP_P1.25mm_Horizontal
L1, L2: 4.7uH; L_Bourns_SRP1245A
R1, R4: 100k; C_0805_2012Metric
R2: 52.3k; C_0805_2012Metric
R3: 10k; C_0805_2012Metric
R5: 31.6k; C_0805_2012Metric
R6: 10.2k; C_0805_2012Metric
R7: 100; C_0805_2012Metric
R8: 200; C_0805_2012Metric
R9: 600; C_0402_1005Metric
SW1: SW_DIP_x03; SW_DIP_SPSTx03_Slide_9.78x9.8mm_W8.61mm_P2.54mm
SW2: SW_SPST; SW_SPST_B3S-1100
U1, U2: ADP2303ARDZ-R7; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm

Connections:
+3.3V: C14.1, C15.1, C17.1, F2.1, J7.1, J8.1, R7.1; also elsewhere on the board
+5V: C5.1, C8.1, C9.1, C13.1, C16.1, C18.1, F1.1, IC1.55 (VIN_(3.6_TO_5.5_VOLTS)), J3.1, J4.1, J5.1, J6.1, R8.1
+12V: C1.1, C2.1, C3.1, C6.1, IC2.5 (VM), IC3.5 (VM), R1.1, R4.1, R9.1, SW2.1 (A), U1.2 (Vin), U1.3 (EN), U2.2 (Vin), U2.3 (EN)
BDC11: IC1.22 (A8), IC2.1 (IN1)
BDC12: IC1.23 (A9), IC2.2 (IN2)
BDC21: IC1.18 (A4), IC3.1 (IN1)
BDC22: IC1.19 (A5), IC3.2 (IN2)
GND: C1.2, C2.2, C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, D1.2, D2.2, D3.1 (K), D4.1 (K), D5.1 (K), IC1.70 (GND_5), IC2.3 (GND), IC3.3 (GND), J3.4, J4.4, J5.4, J6.4, J7.3, J8.3, J9.2, R3.2, R6.2, SW1.1, SW1.2, SW1.3, U1.7 (GND), U1.9 (PADGND), U2.7 (GND), U2.9 (PADGND); also elsewhere on the board
LF_INT: IC1.21 (A7), J8.2
unnamed: C4.1, U2.1 (BST)
unnamed: C4.2, D2.1, L2.1, U2.8 (SW)
unnamed: C7.1, F1.2, L1.2, R2.1
unnamed: C10.1, U1.1 (BST)
unnamed: C10.2, D1.1, L1.1, U1.8 (SW)
unnamed: C11.1, C12.1, F2.2, L2.2, R5.1
unnamed: D3.2 (A), R7.2
unnamed: D4.2 (A), R8.2
unnamed: D5.2 (A), R9.2
unnamed: IC1.24 (A10), SW1.6
unnamed: IC1.25 (A11), SW1.5
unnamed: IC1.26 (A12), SW1.4
unnamed: IC2.4 (OUT2), J1.1
unnamed: IC2.6 (OUT1), J1.2
unnamed: IC3.4 (OUT2), J2.1
unnamed: IC3.6 (OUT1), J2.2
unnamed: J9.1, SW2.2 (B)
unnamed: R1.2, U1.4 (PGOOD)
unnamed: R2.2, R3.1, U1.5 (FB)
unnamed: R4.2, U2.4 (PGOOD)
unnamed: R5.2, R6.1, U2.5 (FB)
RF_INT: IC1.20 (A6), J7.2
RX1: IC1.57 (RX1), J3.3
RX2: IC1.7 (RX2), J4.3
RX3: IC1.15 (A1), J5.3
RX4: IC1.17 (A3), J6.3
TX1: IC1.1 (TX1), J3.2
TX2: IC1.8 (TX2), J4.2
TX3: IC1.14 (A0), J5.2
TX4: IC1.16 (A2), J6.2

Notes on the sheet:
Power & Decoupling
Line Sensors
Voltage Regulators
Motor Drivers
Teensy Microcontroller
Status LEDs
LIDAR Sensors

Board: 2 copper layers, 54 parts (17 on the bottom side), 39 nets.

Other parts of the board:
J10: LINE_RB; PhoenixContact_MSTBA_2,5_3-G_1x03_P5.00mm_Horizontal
J11: LINE_LB; PhoenixContact_MSTBA_2,5_3-G_1x03_P5.00mm_Horizontal

Their connections:
+3.3V: J10.1, J11.1; also elsewhere on the board
GND: J10.3, J11.3; also elsewhere on the board

## KiCad design 3kg/Fewawi/FewawiControlBoard/FewawiControlBoard.kicad_pcb

Board: 2 copper layers, 106.5 x 86.0 mm, 88 parts (0 on the bottom side), 72 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Encoder_Left; JST_PH_S5B-PH-K_1x05_P2.00mm_Horizontal
J2: Encoder_Right; JST_PH_S5B-PH-K_1x05_P2.00mm_Horizontal
J3: DS_FL; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J4: Start Module; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J5: DS_45L; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J6: DS_60L; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J7: DS_90L; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J8: DS_Mid; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J9: LCD_Screen; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J10: DS_45R; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J11: DS_60R; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J12: DS_90R; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J13: DS_FR; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J14: LS_LF1; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J15: LS_RF1; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J16: LS_BL1; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J17: LS_BR1; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J18: LS_PlowLeft; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J19: LS_PlowMid; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J20: LS_LF2; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J21: LS_RF2; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J22: LS_BL2; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J23: LS_BR2; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J24: LS_PlowRight; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J25: SignalsToMD; JST_PH_S2B-PH-K_1x02_P2.00mm_Horizontal
J26: 12vPower; AMASS_XT30U-F_1x02_P5.0mm_Vertical
J27: 5vPower; AMASS_XT30U-F_1x02_P5.0mm_Vertical
Q2, Q3, Q4, Q5, Q6: LTV-826S; DIL8-SMD
R1, R2, R4, R5, R6, R7: 2.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R3: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R8, R9: 2000; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R10, R11, R12, R13, R14, R15, R16, R17, R18: 500; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R19, R20: 1000; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: DEV-16771; MODULE_DEV-16771
U2: Button1; CHERRY_MX1A-11NN_SWITCH
U3: SEN-21325
U4: LMV358IDGKRG4; SOP65P490X110-8N

Connections:
+3.3V: C2.1, C4.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, J4.2, J14.2, J15.2, J16.2, J17.2, J18.2, J19.2, J20.2, J21.2, J22.2, J23.2, J24.2, Q2.6, Q2.8, Q3.6, Q3.8, Q4.6, Q4.8, Q5.6, Q5.8, Q6.8, U1.3.3V_1 (3.3V), U1.3.3V_2 (3.3V), U1.3.3V_3 (3.3V), U2.P$2, U3.2 (3V3)
+5V: C1.2, J1.4, J2.4, J9.2, J27.2, R1.2, R2.2, R4.2, R5.2, R6.2, R7.2, U1.5V, U1.VIN, U4.8 (VCC+)
+12V: C3.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, J3.1, J5.1, J6.1, J7.1, J8.1, J10.1, J11.1, J12.1, J13.1, J26.2
Button1: R3.1, U1.4 (BCLK2), U2.P$1
DS_45L: Q2.5, U1.0 (RX1)
DS_45R: Q4.5, U1.28 (RX7)
DS_60L: Q3.7, U1.3 (LRCLK2)
DS_60R: Q5.5, U1.11 (MOSI)
DS_90L: Q3.5, U1.2 (OUT2)
DS_90R: Q5.7, U1.12 (MISO)
DS_FL: Q2.7, U1.1 (TX1)
DS_FR: Q4.7, U1.29 (TX7)
DS_Mid: Q6.7, U1.10 (CS1)
EncL_Pin2: J1.2, R6.1, U1.13 (SCK)
EncL_Pin3: J1.3, R4.1, U1.5 (IN2)
EncL_Pin5: J1.5, R1.1, U1.6 (OUT1D)
EncR_Pin2: J2.2, R7.1, U1.33 (MCLK2)
EncR_Pin3: J2.3, R5.1, U1.9 (OUT1C)
EncR_Pin5: J2.5, R2.1, U1.36 (CS2)
GND: C1.1, C2.2, C3.1, C4.2, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, J1.1, J2.1, J3.2, J4.1, J5.2, J6.2, J7.2, J8.2, J9.1, J10.2, J11.2, J12.2, J13.2, J14.1, J15.1, J16.1, J17.1, J18.1, J19.1, J20.1, J21.1, J22.1, J23.1, J24.1, J26.1, J27.1, Q2.2, Q2.4, Q3.2, Q3.4, Q4.2, Q4.4, Q5.2, Q5.4, Q6.2, R3.2, R8.1, R9.2, U1.GND1 (GND), U1.GND2 (GND), U1.GND3 (GND), U1.GND4 (GND), U1.GND5 (GND), U1.USB_GND1 (USB_GND), U1.USB_GND2 (USB_GND), U3.1 (GND), U3.10 (SCX), U3.11 (SDX), U4.4 (GND)
IMU_CS: U1.37 (CS3), U3.6 (CS)
IMU_INT1: U1.8 (TX2), U3.8 (INT1)
IMU_INT2: U1.7 (RX2), U3.7 (INT2)
IMU_SCL: U1.19 (A5), U3.4 (SCL)
IMU_SDA: U1.18 (A4), U3.3 (SDA)
LCD_SCL: J9.4, U1.24 (A10)
LCD_SDA: J9.3, U1.25 (A11)
LS_BL1: J16.3, U1.40 (A16)
LS_BL2: J22.3, U1.41 (A17)
LS_BR1: J17.3, U1.26 (A12)
LS_BR2: J23.3, U1.27 (A13)
LS_LF1: J14.3, U1.22 (A8)
LS_LF2: J20.3, U1.21 (A7)
LS_PlowLeft: J18.3, U1.20 (A6)
LS_PlowMid: J19.3, U1.17 (A3)
LS_PlowRight: J24.3, U1.16 (A2)
LS_RF1: J15.3, U1.14 (A0)
LS_RF2: J21.3, U1.15 (A1)
MD_InputSignal1: R20.2, U1.39 (A15), U4.5
MD_InputSignal2: R19.2, U1.38 (A14), U4.3
unnamed: D1.1 (K), R10.1
unnamed: D2.1 (K), R11.1
unnamed: D3.1 (K), R12.1
unnamed: D4.1 (K), R13.1
unnamed: D5.1 (K), R14.1
unnamed: D6.1 (K), R15.1
unnamed: D7.1 (K), R16.1
unnamed: D8.1 (K), R17.1
unnamed: D9.1 (K), R18.1
unnamed: Q2.1, R10.2
unnamed: Q2.3, R11.2
unnamed: Q3.1, R12.2
unnamed: Q3.3, R13.2
unnamed: Q4.1, R14.2
unnamed: Q4.3, R15.2
unnamed: Q5.1, R16.2
unnamed: Q5.3, R17.2
unnamed: Q6.1, R18.2
unnamed: R8.2, U4.2
unnamed: R9.1, U4.6
OCT_45L: D2.2 (A), J5.3
OCT_45R: D6.2 (A), J10.3
OCT_60L: D3.2 (A), J6.3
OCT_60R: D8.2 (A), J11.3
OCT_90L: D4.2 (A), J7.3
OCT_90R: D7.2 (A), J12.3
OCT_FL: D1.2 (A), J3.3
OCT_FR: D5.2 (A), J13.3
OCT_Mid: D9.2 (A), J8.3
Signal1: J25.1, R20.1, U4.7
Signal2: J25.2, R19.1, U4.1
StartMod: J4.3, U1.23 (A9)

## KiCad design 3kg/Fewawi/FewawiOwO/FewawiOwO.kicad_pcb

Board: 2 copper layers, 160.0 x 90.0 mm, 106 parts (0 on the bottom side), 82 nets.

Parts:
C1, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32: 0.1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C2: 10uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C4: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9: LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
F1: FuseNotMotors; FUSC3215X83N
F2: Fuse; 0456050.DRSD
J1: LS_LF1; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J2: LS_LF2; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J3: LS_RF1; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J4: LS_RF2; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J5: LS_BL1; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J6: LS_BL2; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J7: LCD_Screen; JST_PH_S4B-PH-K_1x04_P2.00mm_Horizontal
J8: Start Module; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J9: DS_FL; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J10: DS_FR; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J11: DS_45L; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J12: DS_45R; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J13: DS_60L; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J14: DS_60R; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J15: DS_90L; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J16: DS_90R; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J17: DS_Mid; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J18: LS_BR2; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J19: LS_BR1; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J20: LS_PlowLeft; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J21: LS_PlowMid; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J22: LS_PlowRight; JST_PH_S3B-PH-K_1x03_P2.00mm_Horizontal
J23: Encoder_Left; JST_PH_S5B-PH-K_1x05_P2.00mm_Horizontal
J24: Battery; AMASS_XT60-F_1x02_P7.20mm_Vertical
J25: Encoder_Right; JST_PH_S5B-PH-K_1x05_P2.00mm_Horizontal
J26: MD_Power; PhoenixContact_MSTBA_2,5_2-G_1x02_P5.00mm_Horizontal
J27: MD_SIgnals; PhoenixContact_MSTBA_2,5_4-G_1x04_P5.00mm_Horizontal
PS1: TSR_1-2450; CONV_TSR_1-2450
Q1: SQM40P10-40L_GE3; SQM40P1040L_GE3
Q2: SQ2318AES-T1_BE3; SOT95P237X112-3N
Q3, Q4, Q5, Q6, Q7, Q8: LTV-826S; DIL8-SMD
R1: 15k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R2, R3, R4: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R5, R6, R7, R8, R9, R10, R11, R12, R13: 500; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R14: 4.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R16, R17: 100; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R18, R19, R20, R21, R22, R23: 2.7k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_SPST; SW_G-107-0513
U1: DEV-16771; MODULE_DEV-16771
U2: Button1; CHERRY_MX1A-11NN_SWITCH
U4: SEN-21325
U5: L7812CV; CONV_TSR_1-2450

Connections:
34V: C2.1, C3.1, C4.1, Q1.2 (D)
+3.3V: C17.1, C19.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, J1.2, J2.2, J3.2, J4.2, J5.2, J6.2, J8.2, J18.2, J19.2, J20.2, J21.2, J22.2, Q3.6, Q3.8, Q4.6, Q4.8, Q5.6, Q5.8, Q6.6, Q6.8, Q7.8, U1.3.3V_1 (3.3V), U1.3.3V_2 (3.3V), U1.3.3V_3 (3.3V), U2.P$2, U4.2 (3V3)
+5V: C1.2, C5.1, C18.2, J7.2, J23.4, J25.4, J27.2, PS1.3 (+VOUT), Q8.6, Q8.8, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, U1.5V, U1.VIN
+12V: C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C32.2, J9.1, J10.1, J11.1, J12.1, J13.1, J14.1, J15.1, J16.1, J17.1, U5.3 (OUT)
+34V: F1.2, J26.1
Button1: R14.1, U1.4 (BCLK2), U2.P$1
DS_45L: Q3.5, U1.12 (MISO)
DS_45R: Q5.5, U1.3 (LRCLK2)
DS_60L: Q4.7, U1.28 (RX7)
DS_60R: Q6.5, U1.1 (TX1)
DS_90L: Q4.5, U1.29 (TX7)
DS_90R: Q6.7, U1.0 (RX1)
DS_FL: Q3.7, U1.11 (MOSI)
DS_FR: Q5.7, U1.2 (OUT2)
DS_Mid: Q7.7, U1.10 (CS1)
EncL_Pin2: J23.2, R20.1, U1.13 (SCK)
EncL_Pin3: J23.3, R19.1, U1.9 (OUT1C)
EncL_Pin5: J23.5, R18.1, U1.6 (OUT1D)
EncR_Pin2: J25.2, R23.1, U1.22 (A8)
EncR_Pin3: J25.3, R22.1, U1.5 (IN2)
EncR_Pin5: J25.5, R21.1, U1.36 (CS2)
GND: C1.1, C2.2, C3.2, C5.2, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.2, C18.1, C19.2, C20.1, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, J1.1, J2.1, J3.1, J4.1, J5.1, J6.1, J7.1, J8.1, J9.2, J10.2, J11.2, J12.2, J13.2, J14.2, J15.2, J16.2, J17.2, J18.1, J19.1, J20.1, J21.1, J22.1, J23.1, J24.2, J25.1, J27.1, PS1.2 (GND), Q2.2 (S), Q3.2, Q3.4, Q4.2, Q4.4, Q5.2, Q5.4, Q6.2, Q6.4, Q7.2, Q8.2, Q8.4, R3.2, R14.2, U1.GND1 (GND), U1.GND2 (GND), U1.GND3 (GND), U1.GND4 (GND), U1.GND5 (GND), U1.USB_GND1 (USB_GND), U1.USB_GND2 (USB_GND), U4.1 (GND)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
IMU_CS: U1.37 (CS3), U4.6 (CS)
IMU_INT1: U1.8 (TX2), U4.8 (INT1)
IMU_INT2: U1.7 (RX2), U4.7 (INT2)
IMU_SCL: U1.19 (A5), U4.4 (SCL)
IMU_SDA: U1.18 (A4), U4.3 (SDA)
LCD_SCL: J7.4, U1.24 (A10)
LCD_SDA: J7.3, U1.25 (A11)
LS_BL1: J5.3, U1.41 (A17)
LS_BL2: J6.3, U1.40 (A16)
LS_BR1: J19.3, U1.21 (A7)
LS_BR2: J18.3, U1.23 (A9)
LS_LF1: J1.3, U1.26 (A12)
LS_LF2: J2.3, U1.27 (A13)
LS_PlowLeft: J20.3, U1.16 (A2)
LS_PlowMid: J21.3, U1.20 (A6)
LS_PlowRight: J22.3, U1.17 (A3)
LS_RF1: J3.3, U1.15 (A1)
LS_RF2: J4.3, U1.14 (A0)
MD_InputSignal1: R17.1, U1.38 (A14)
MD_InputSignal2: R16.1, U1.39 (A15)
unnamed: D1.1 (K), R5.1
unnamed: D2.1 (K), R6.1
unnamed: D3.1 (K), R7.1
unnamed: D4.1 (K), R8.1
unnamed: D5.1 (K), R9.1
unnamed: D6.1 (K), R10.1
unnamed: D7.1 (K), R11.1
unnamed: D8.1 (K), R12.1
unnamed: D9.1 (K), R13.1
unnamed: F2.2, J24.1
unnamed: C7.2, J26.2
unnamed: C16.2, C20.2, F1.1, PS1.1 (+VIN), U5.1 (IN)
unnamed: C4.2, Q1.1 (G), R1.1, R2.1
unnamed: F2.1, Q1.3 (S), R2.2, SW1.2 (B)
unnamed: Q2.3 (D), R1.2
unnamed: Q2.1 (G), R3.1, R4.1
unnamed: Q3.1, R5.2
unnamed: Q3.3, R6.2
unnamed: Q4.1, R7.2
unnamed: Q4.3, R8.2
unnamed: Q5.1, R9.2
unnamed: Q5.3, R10.2
unnamed: Q6.1, R11.2
unnamed: Q6.3, R12.2
unnamed: Q7.1, R13.2
unnamed: Q8.1, R16.2
unnamed: Q8.3, R17.2
unnamed: R4.2, SW1.1 (A)
OCT_45L: D2.2 (A), J11.3
OCT_45R: D6.2 (A), J12.3
OCT_60L: D3.2 (A), J13.3
OCT_60R: D8.2 (A), J14.3
OCT_90L: D4.2 (A), J15.3
OCT_90R: D7.2 (A), J16.3
OCT_FL: D1.2 (A), J9.3
OCT_FR: D5.2 (A), J10.3
OCT_Mid: D9.2 (A), J17.3
OCT_Signal1: J27.3, Q8.5
OCT_Signal2: J27.4, Q8.7
StartMod: J8.3, U1.33 (MCLK2)
