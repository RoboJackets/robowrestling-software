File: Radio/Radii/Radii.brd (EAGLE design)
At the start: 42.6 x 44.3 mm, 22 parts, among them J1 10118193-0001LF, U2 ATMEGA32U4-AUR, U4 IND_1255AY-3R9N=P3

Commit message: Updated radio board
Parts:
- moved JP1 20.0 mm to (40.6, 9.23), turned to 270 degrees
- moved JP2 12.0 mm to (41.0, 32.0)
- moved C12 6.00 mm to (13.8, 11.9)
- moved C11 3.40 mm to (13.8, 1.25)
- moved C10 2.48 mm to (13.8, 3.52)
- moved C2 2.30 mm to (13.8, 5.82)
- moved C3 2.24 mm to (36.7, 16.5)
Routing:
- net GND: track 13.4 -> 34.4 mm, vias 0 -> 4
- net N$5: track 0.00 -> 2.05 mm
